<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xmlns="http://autosar.org/schema/r4.0" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-1-1.xsd">
  <ar-packages>
    <ar-package UUID="5983c226-f5b2-4ba1-958d-32fe5f2fde51">
      <short-name>AUTOSAR</short-name>
      <ar-packages>
        <ar-package>
          <short-name>AUTOSAR_GenDef</short-name>
          <ar-packages>
            <ar-package>
              <short-name>BaseTypes</short-name>
              <category>STANDARD</category>
              <elements>
                <sw-base-type>
                  <short-name>void</short-name>
                  <long-name>
                    <l-4 L="EN">void</l-4>
                    </long-name>
                  <category>VOID</category>
                  <base-type-encoding>VOID</base-type-encoding>
                  <native-declaration>void</native-declaration>
                  </sw-base-type>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package>
          <short-name>AUTOSAR_PhysicalUnits</short-name>
          <long-name>
            <l-4 L="EN">AUTOSAR</l-4>
            </long-name>
          <ar-packages>
            <ar-package>
              <short-name>PhysicalDimensions</short-name>
              <category>STANDARD</category>
              <elements>
                <physical-dimension>
                  <short-name>Amnt1</short-name>
                  <long-name>
                    <l-4 L="EN">Quantity of substance</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>I1</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Current</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Illmn1</short-name>
                  <long-name>
                    <l-4 L="EN">Luminous intensity</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>1</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1</short-name>
                  <long-name>
                    <l-4 L="EN">Length</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1M1TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Force</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1M1TiNeg2INeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Permeability</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>-2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1M1TiNeg2_1</short-name>
                  <long-name>
                    <l-4 L="EN">Electrical Energy Consumption</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1M1TiNeg3INeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Field Strength / Electric intensity</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>-1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1M1TiNeg3TNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Thermal Conductivity</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>-1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Velocity</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Acceleration</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len1TiNeg3</short-name>
                  <long-name>
                    <l-4 L="EN">Acceleration Time Gradient</l-4>
                    </long-name>
                  <length-exp>1</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2</short-name>
                  <long-name>
                    <l-4 L="EN">Area</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1</short-name>
                  <long-name>
                    <l-4 L="EN">Moment of Inertia</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Angular Momentum</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Torque</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2AmntNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Molar Energy</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>-1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2INeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Magnetic Flux</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>-1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2INeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Inductance</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>-2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2TNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Heat Capacity</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>-1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2TNeg1AmntNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Molar Heat Capacity</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>-1</temperature-exp>
                  <molar-amount-exp>-1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg2_1</short-name>
                  <long-name>
                    <l-4 L="EN">Energy</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg3</short-name>
                  <long-name>
                    <l-4 L="EN">Torque Time Gradient</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg3INeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Voltage</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>-1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg3INeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Resistance</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>-2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg3_1</short-name>
                  <long-name>
                    <l-4 L="EN">Power</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg4</short-name>
                  <long-name>
                    <l-4 L="EN">Power Time Gradient</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-4</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2M1TiNeg4INeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Voltage Time Gradient</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-4</time-exp>
                  <current-exp>-1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2Ti1</short-name>
                  <long-name>
                    <l-4 L="EN">Kinematic Viscosity</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Specific Heat</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2TiNeg2TNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Specific Heat Capacity</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>-1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len2_1</short-name>
                  <long-name>
                    <l-4 L="EN">Volume Per Distance / Fuel Consumption</l-4>
                    </long-name>
                  <length-exp>2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len3</short-name>
                  <long-name>
                    <l-4 L="EN">Volume</l-4>
                    </long-name>
                  <length-exp>3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len3MNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Specific Volume</l-4>
                    </long-name>
                  <length-exp>3</length-exp>
                  <mass-exp>-1</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len3TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Volumetric Flow</l-4>
                    </long-name>
                  <length-exp>3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Len3TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Volumetric Flow Gradient</l-4>
                    </long-name>
                  <length-exp>3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Inverse Length</l-4>
                    </long-name>
                  <length-exp>-1</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg1M1TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Dynamic Viscosity</l-4>
                    </long-name>
                  <length-exp>-1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg1M1TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Pressure</l-4>
                    </long-name>
                  <length-exp>-1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg1M1TiNeg2_1</short-name>
                  <long-name>
                    <l-4 L="EN">Pressure by Angle</l-4>
                    </long-name>
                  <length-exp>-1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg1M1TiNeg3</short-name>
                  <long-name>
                    <l-4 L="EN">Pressure Gradient</l-4>
                    </long-name>
                  <length-exp>-1</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg2Illmn1</short-name>
                  <long-name>
                    <l-4 L="EN">Illuminance</l-4>
                    </long-name>
                  <length-exp>-2</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>1</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg2MNeg1Ti3I2</short-name>
                  <long-name>
                    <l-4 L="EN">Electrical Conductance</l-4>
                    </long-name>
                  <length-exp>-2</length-exp>
                  <mass-exp>-1</mass-exp>
                  <time-exp>3</time-exp>
                  <current-exp>2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg2MNeg1Ti4I2</short-name>
                  <long-name>
                    <l-4 L="EN">Capacitance</l-4>
                    </long-name>
                  <length-exp>-2</length-exp>
                  <mass-exp>-1</mass-exp>
                  <time-exp>4</time-exp>
                  <current-exp>2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3Amnt1</short-name>
                  <long-name>
                    <l-4 L="EN">Concentration</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3M1</short-name>
                  <long-name>
                    <l-4 L="EN">Mass Density</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3MNeg1Ti2I2</short-name>
                  <long-name>
                    <l-4 L="EN">Electrical Conductivity Gradient</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>-1</mass-exp>
                  <time-exp>2</time-exp>
                  <current-exp>2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3MNeg1Ti3I2</short-name>
                  <long-name>
                    <l-4 L="EN">Electrical Conductivity</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>-1</mass-exp>
                  <time-exp>3</time-exp>
                  <current-exp>2</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3Ti1I1</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Charge Density</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>1</time-exp>
                  <current-exp>1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3Ti1I1_1</short-name>
                  <long-name>
                    <l-4 L="EN">Pressure per Voltage</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>1</time-exp>
                  <current-exp>1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg3TiNeg1Amnt1</short-name>
                  <long-name>
                    <l-4 L="EN">Reaction Rate</l-4>
                    </long-name>
                  <length-exp>-3</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>LenNeg4M1TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Pressure per Volumetric Flow / Flow Resistance</l-4>
                    </long-name>
                  <length-exp>-4</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1</short-name>
                  <long-name>
                    <l-4 L="EN">Mass</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1AmntNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Molar Mass</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>-1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Mass Flow</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1TiNeg1_1</short-name>
                  <long-name>
                    <l-4 L="EN">Translational Dumping</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Surface Tension</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1TiNeg2INeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Magnetic Flux Density, Magnetic Induction</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>-1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>M1TiNeg3TNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Heat Transfer Coefficient</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>1</mass-exp>
                  <time-exp>-3</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>-1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>NoDimension</short-name>
                  <long-name>
                    <l-4 L="EN">Dimensionless</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>NoDimension_1</short-name>
                  <long-name>
                    <l-4 L="EN">Ratio</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>NoDimension_2</short-name>
                  <long-name>
                    <l-4 L="EN">Angle</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>NoDimension_5</short-name>
                  <long-name>
                    <l-4 L="EN">Logarithmic Ratio</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>NoDimension_6</short-name>
                  <long-name>
                    <l-4 L="EN">Amount of Data</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>T1</short-name>
                  <long-name>
                    <l-4 L="EN">Absolute Temperature</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>T1I1</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Charge</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>1</time-exp>
                  <current-exp>1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>T1_1</short-name>
                  <long-name>
                    <l-4 L="EN">Relative Temperature, Temperature Difference</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>0</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>Ti1</short-name>
                  <long-name>
                    <l-4 L="EN">Time</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1</short-name>
                  <long-name>
                    <l-4 L="EN">Frequency</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1Amnt1</short-name>
                  <long-name>
                    <l-4 L="EN">Catalytic Activity</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>1</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1I1</short-name>
                  <long-name>
                    <l-4 L="EN">Electric Current Gradient</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>1</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1T1</short-name>
                  <long-name>
                    <l-4 L="EN">Temperature Gradient</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>1</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1_1</short-name>
                  <long-name>
                    <l-4 L="EN">Ratio Gradient</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1_2</short-name>
                  <long-name>
                    <l-4 L="EN">Rotational Speed</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg1_3</short-name>
                  <long-name>
                    <l-4 L="EN">Transfer Rate</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-1</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                <physical-dimension>
                  <short-name>TiNeg2</short-name>
                  <long-name>
                    <l-4 L="EN">Rotational Speed Gradient</l-4>
                    </long-name>
                  <length-exp>0</length-exp>
                  <mass-exp>0</mass-exp>
                  <time-exp>-2</time-exp>
                  <current-exp>0</current-exp>
                  <temperature-exp>0</temperature-exp>
                  <molar-amount-exp>0</molar-amount-exp>
                  <luminous-intensity-exp>0</luminous-intensity-exp>
                  </physical-dimension>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>Units</short-name>
              <category>STANDARD</category>
              <reference-bases>
                <reference-base>
                  <short-label>PhysicalDimensions</short-label>
                  <is-default>false</is-default>
                  <package-ref DEST="AR-PACKAGE">/AUTOSAR/AUTOSAR_PhysicalUnits/PhysicalDimensions</package-ref>
                  </reference-base>
                </reference-bases>
              <elements>
                <unit>
                  <short-name>Ampr</short-name>
                  <long-name>
                    <l-4 L="EN">Ampere</l-4>
                    </long-name>
                  <display-name>A</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>AmprPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Ampere Per Second</l-4>
                    </long-name>
                  <display-name>A/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>AmprSec</short-name>
                  <long-name>
                    <l-4 L="EN">Amperesecond</l-4>
                    </long-name>
                  <display-name>As</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">T1I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Bar</short-name>
                  <long-name>
                    <l-4 L="EN">Bar</l-4>
                    </long-name>
                  <display-name>bar</display-name>
                  <factor-si-to-unit>1E-05</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>BarPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Bar Per Second</l-4>
                    </long-name>
                  <display-name>bar/s</display-name>
                  <factor-si-to-unit>1E-05</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Bel</short-name>
                  <long-name>
                    <l-4 L="EN">Bel</l-4>
                    </long-name>
                  <display-name>B</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_5</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Bit</short-name>
                  <long-name>
                    <l-4 L="EN">Bit</l-4>
                    </long-name>
                  <display-name>bit</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_6</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>BitPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Bit Per Second</l-4>
                    </long-name>
                  <display-name>bit/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>BytPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Byte Per Second</l-4>
                    </long-name>
                  <display-name>Byte/s</display-name>
                  <factor-si-to-unit>0.125</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Byte</short-name>
                  <long-name>
                    <l-4 L="EN">Byte</l-4>
                    </long-name>
                  <display-name>Byte</display-name>
                  <factor-si-to-unit>0.125</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_6</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Cd</short-name>
                  <long-name>
                    <l-4 L="EN">Candela</l-4>
                    </long-name>
                  <display-name>cd</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Illmn1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>CentiMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Centimeter</l-4>
                    </long-name>
                  <display-name>cm</display-name>
                  <factor-si-to-unit>100</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>CentiMtrSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Square Centimeter</l-4>
                    </long-name>
                  <display-name>cm^2</display-name>
                  <factor-si-to-unit>10000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Coulomb</short-name>
                  <long-name>
                    <l-4 L="EN">Coulomb</l-4>
                    </long-name>
                  <display-name>C</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">T1I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Day</short-name>
                  <long-name>
                    <l-4 L="EN">Day</l-4>
                    </long-name>
                  <display-name>d</display-name>
                  <factor-si-to-unit>1.15740740740741E-05</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>DeciBel</short-name>
                  <long-name>
                    <l-4 L="EN">Decibel</l-4>
                    </long-name>
                  <display-name>dB</display-name>
                  <factor-si-to-unit>10</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_5</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Deg</short-name>
                  <long-name>
                    <l-4 L="EN">Degree</l-4>
                    </long-name>
                  <display-name>°</display-name>
                  <factor-si-to-unit>360</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>DegCgrd</short-name>
                  <long-name>
                    <l-4 L="EN">Degree Celsius (Absolute Temperature)</l-4>
                    </long-name>
                  <display-name>°C</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>-273.15</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">T1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>DegPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Degree Per Sec</l-4>
                    </long-name>
                  <display-name>°/s</display-name>
                  <factor-si-to-unit>360</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Frd</short-name>
                  <long-name>
                    <l-4 L="EN">Farad</l-4>
                    </long-name>
                  <display-name>F</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti4I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Gr</short-name>
                  <long-name>
                    <l-4 L="EN">Gram</l-4>
                    </long-name>
                  <display-name>g</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>GrPerLtr</short-name>
                  <long-name>
                    <l-4 L="EN">Gram Per Liter</l-4>
                    </long-name>
                  <display-name>g/l</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>GrPerMol</short-name>
                  <long-name>
                    <l-4 L="EN">Gram Per Mole</l-4>
                    </long-name>
                  <display-name>g/mol</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1AmntNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>GrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Gram Per Second</l-4>
                    </long-name>
                  <display-name>g/s</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>HectoPa</short-name>
                  <long-name>
                    <l-4 L="EN">Hectopascal</l-4>
                    </long-name>
                  <display-name>hPa</display-name>
                  <factor-si-to-unit>0.01</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>HectoPaPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Hectopascal Per Second</l-4>
                    </long-name>
                  <display-name>hPa/s</display-name>
                  <factor-si-to-unit>0.01</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>HectoPaPerVolt</short-name>
                  <long-name>
                    <l-4 L="EN">Hectopascal Per Volt</l-4>
                    </long-name>
                  <display-name>hPa/V</display-name>
                  <factor-si-to-unit>0.01</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3Ti1I1_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>HectoPaSecPerMtrCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Hectopascal Per Cubic Meter Per Second</l-4>
                    </long-name>
                  <display-name>hPa/((m^3)/s)</display-name>
                  <factor-si-to-unit>0.01</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg4M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Henry</short-name>
                  <long-name>
                    <l-4 L="EN">Henry</l-4>
                    </long-name>
                  <display-name>H</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>HenryPerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Henry Per Meter</l-4>
                    </long-name>
                  <display-name>H/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg2INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Hr</short-name>
                  <long-name>
                    <l-4 L="EN">Hour</l-4>
                    </long-name>
                  <display-name>h</display-name>
                  <factor-si-to-unit>0.000277777777777778</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Hz</short-name>
                  <long-name>
                    <l-4 L="EN">Hertz</l-4>
                    </long-name>
                  <display-name>Hz</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Jou</short-name>
                  <long-name>
                    <l-4 L="EN">Joule</l-4>
                    </long-name>
                  <display-name>J</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>JouPerKelvin</short-name>
                  <long-name>
                    <l-4 L="EN">Joule Per Kelvin</l-4>
                    </long-name>
                  <display-name>J/K</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2TNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>JouPerKiloGr</short-name>
                  <long-name>
                    <l-4 L="EN">Joule Per Kilogram</l-4>
                    </long-name>
                  <display-name>J/kg</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>JouPerKiloGrPerKelvin</short-name>
                  <long-name>
                    <l-4 L="EN">Joule Per Kilogram Per Kelvin</l-4>
                    </long-name>
                  <display-name>J/(kg*K)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2TiNeg2TNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>JouPerMol</short-name>
                  <long-name>
                    <l-4 L="EN">Joule Per Mole</l-4>
                    </long-name>
                  <display-name>J/mol</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2AmntNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>JouPerMolPerKelvin</short-name>
                  <long-name>
                    <l-4 L="EN">Joule Per Mole Per Kelvin</l-4>
                    </long-name>
                  <display-name>J/(mol*K)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2TNeg1AmntNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Kat</short-name>
                  <long-name>
                    <l-4 L="EN">Katal</l-4>
                    </long-name>
                  <display-name>kat</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KelvinAbslt</short-name>
                  <long-name>
                    <l-4 L="EN">Kelvin (Absolute Temperature)</l-4>
                    </long-name>
                  <display-name>K</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">T1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KelvinPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Kelvin Per Second</l-4>
                    </long-name>
                  <display-name>K/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1T1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KelvinRel</short-name>
                  <long-name>
                    <l-4 L="EN">Kelvin (Relative Temperature, Temperature Difference)</l-4>
                    </long-name>
                  <display-name>K</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">T1_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloBitPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Kilobit Per Second</l-4>
                    </long-name>
                  <display-name>kbit/s</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloGr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilogram</l-4>
                    </long-name>
                  <display-name>kg</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloGrPerHr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilogram Per Hour</l-4>
                    </long-name>
                  <display-name>kg/h</display-name>
                  <factor-si-to-unit>3600</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloGrPerMtrCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Kilogram Per Cubic Meter</l-4>
                    </long-name>
                  <display-name>kg/(m^3)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloGrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Kilogram Per Second</l-4>
                    </long-name>
                  <display-name>kg/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloGrSqrMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilogram Square Meter</l-4>
                    </long-name>
                  <display-name>kg*(m^2)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloHz</short-name>
                  <long-name>
                    <l-4 L="EN">Kilohertz</l-4>
                    </long-name>
                  <display-name>kHz</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloJou</short-name>
                  <long-name>
                    <l-4 L="EN">Kilojoule</l-4>
                    </long-name>
                  <display-name>kJ</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilometer</l-4>
                    </long-name>
                  <display-name>km</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloMtrPerHr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilometer Per Hour</l-4>
                    </long-name>
                  <display-name>km/h</display-name>
                  <factor-si-to-unit>3.6</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloMtrPerHrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Kilometer Per Hour Per Second</l-4>
                    </long-name>
                  <display-name>(km/h)/s</display-name>
                  <factor-si-to-unit>3.6</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloNwt</short-name>
                  <long-name>
                    <l-4 L="EN">Kilonewton</l-4>
                    </long-name>
                  <display-name>kN</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloNwtMtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Kilonewtonmeter Per Second</l-4>
                    </long-name>
                  <display-name>(kN*m)/s</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloOhm</short-name>
                  <long-name>
                    <l-4 L="EN">Kiloohm</l-4>
                    </long-name>
                  <display-name>kΩ</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloVolt</short-name>
                  <long-name>
                    <l-4 L="EN">Kilovolt</l-4>
                    </long-name>
                  <display-name>kV</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloWatt</short-name>
                  <long-name>
                    <l-4 L="EN">Kilowatt</l-4>
                    </long-name>
                  <display-name>kW</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloWattHr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilowatthour</l-4>
                    </long-name>
                  <display-name>kWh</display-name>
                  <factor-si-to-unit>2.77777777777778E-07</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>KiloWattHrPer100KiloMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Kilowatthour Per 100 Kilometer</l-4>
                    </long-name>
                  <display-name>kWh/(100*km)</display-name>
                  <factor-si-to-unit>0.0277777777777778</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Ltr</short-name>
                  <long-name>
                    <l-4 L="EN">Liter</l-4>
                    </long-name>
                  <display-name>l</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>LtrPer100KiloMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Liter Per 100 Kilometer</l-4>
                    </long-name>
                  <display-name>l/(100km)</display-name>
                  <factor-si-to-unit>100000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>LtrPerHr</short-name>
                  <long-name>
                    <l-4 L="EN">Liter Per Hour</l-4>
                    </long-name>
                  <display-name>l/h</display-name>
                  <factor-si-to-unit>3600000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>LtrPerKiloMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Liter Per Kilometer</l-4>
                    </long-name>
                  <display-name>l/km</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaBitPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Megabit Per Second</l-4>
                    </long-name>
                  <display-name>Mbit/s</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaHz</short-name>
                  <long-name>
                    <l-4 L="EN">Megahertz</l-4>
                    </long-name>
                  <display-name>MHz</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaJou</short-name>
                  <long-name>
                    <l-4 L="EN">Megajoule</l-4>
                    </long-name>
                  <display-name>MJ</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaOhm</short-name>
                  <long-name>
                    <l-4 L="EN">Megaohm</l-4>
                    </long-name>
                  <display-name>MΩ</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaPa</short-name>
                  <long-name>
                    <l-4 L="EN">Megapascal</l-4>
                    </long-name>
                  <display-name>MPa</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MegaWatt</short-name>
                  <long-name>
                    <l-4 L="EN">Megawatt</l-4>
                    </long-name>
                  <display-name>MW</display-name>
                  <factor-si-to-unit>1E-06</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroAmpr</short-name>
                  <long-name>
                    <l-4 L="EN">Microampere</l-4>
                    </long-name>
                  <display-name>µA</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroFrd</short-name>
                  <long-name>
                    <l-4 L="EN">Microfarad</l-4>
                    </long-name>
                  <display-name>µF</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti4I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroGr</short-name>
                  <long-name>
                    <l-4 L="EN">Microgram</l-4>
                    </long-name>
                  <display-name>µg</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroJou</short-name>
                  <long-name>
                    <l-4 L="EN">Microjoule</l-4>
                    </long-name>
                  <display-name>µJ</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroLtr</short-name>
                  <long-name>
                    <l-4 L="EN">Microliter</l-4>
                    </long-name>
                  <display-name>µl</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroLtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Microliter Per Second</l-4>
                    </long-name>
                  <display-name>µl/s</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Micrometer</l-4>
                    </long-name>
                  <display-name>µm</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroSec</short-name>
                  <long-name>
                    <l-4 L="EN">Microsecond</l-4>
                    </long-name>
                  <display-name>µs</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MicroTesla</short-name>
                  <long-name>
                    <l-4 L="EN">Microtesla</l-4>
                    </long-name>
                  <display-name>µT</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg2INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliAmpr</short-name>
                  <long-name>
                    <l-4 L="EN">Milliampere</l-4>
                    </long-name>
                  <display-name>mA/s</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliAmprPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Milliampere Per Second</l-4>
                    </long-name>
                  <display-name>mA/s</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1I1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliBar</short-name>
                  <long-name>
                    <l-4 L="EN">Millibar</l-4>
                    </long-name>
                  <display-name>mbar</display-name>
                  <factor-si-to-unit>0.01</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliFrd</short-name>
                  <long-name>
                    <l-4 L="EN">Millifarad</l-4>
                    </long-name>
                  <display-name>mF</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti4I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliGr</short-name>
                  <long-name>
                    <l-4 L="EN">Milligram</l-4>
                    </long-name>
                  <display-name>mg</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliGrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Milligram Per Second</l-4>
                    </long-name>
                  <display-name>mg/s</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliJou</short-name>
                  <long-name>
                    <l-4 L="EN">Millijoule</l-4>
                    </long-name>
                  <display-name>mJ</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliLtr</short-name>
                  <long-name>
                    <l-4 L="EN">Milliliter</l-4>
                    </long-name>
                  <display-name>ml</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Millimeter</l-4>
                    </long-name>
                  <display-name>mm</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliMtrCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Millimeter</l-4>
                    </long-name>
                  <display-name>mm^3</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliMtrCubdPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Millimeter Per Second</l-4>
                    </long-name>
                  <display-name>(mm^3)/s</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliOhm</short-name>
                  <long-name>
                    <l-4 L="EN">Milliohm</l-4>
                    </long-name>
                  <display-name>mΩ</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliSec</short-name>
                  <long-name>
                    <l-4 L="EN">Millisecond</l-4>
                    </long-name>
                  <display-name>ms</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliTesla</short-name>
                  <long-name>
                    <l-4 L="EN">Millitesla</l-4>
                    </long-name>
                  <display-name>mT</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg2INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliVolt</short-name>
                  <long-name>
                    <l-4 L="EN">Millivolt</l-4>
                    </long-name>
                  <display-name>mV</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliVoltPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Millivolt Per Second</l-4>
                    </long-name>
                  <display-name>mV/s</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg4INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MilliWatt</short-name>
                  <long-name>
                    <l-4 L="EN">Milliwatt</l-4>
                    </long-name>
                  <display-name>mW</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Mins</short-name>
                  <long-name>
                    <l-4 L="EN">Minute</l-4>
                    </long-name>
                  <display-name>min</display-name>
                  <factor-si-to-unit>0.0166666666666667</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Ml</short-name>
                  <long-name>
                    <l-4 L="EN">Mile</l-4>
                    </long-name>
                  <display-name>mile</display-name>
                  <factor-si-to-unit>0.000621371192237333</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MlPerHr</short-name>
                  <long-name>
                    <l-4 L="EN">Miles Per Hour</l-4>
                    </long-name>
                  <display-name>mph</display-name>
                  <factor-si-to-unit>2.2369362920544</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Mol</short-name>
                  <long-name>
                    <l-4 L="EN">Mole</l-4>
                    </long-name>
                  <display-name>mol</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MolPerLtr</short-name>
                  <long-name>
                    <l-4 L="EN">Mole Per Liter</l-4>
                    </long-name>
                  <display-name>mol/l</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MolPerLtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Mol Per Liter Per Second</l-4>
                    </long-name>
                  <display-name>(mol/l)/s</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3TiNeg1Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MolPerMtrCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Mole Per Cubic Meter</l-4>
                    </long-name>
                  <display-name>mol/(m^3)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MolPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Mole Per Second</l-4>
                    </long-name>
                  <display-name>mol/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1Amnt1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Mtr</short-name>
                  <long-name>
                    <l-4 L="EN">Meter</l-4>
                    </long-name>
                  <display-name>m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Meter</l-4>
                    </long-name>
                  <display-name>m^3</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrCubdPerHr</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Meter Per Hour</l-4>
                    </long-name>
                  <display-name>(m^3)/h</display-name>
                  <factor-si-to-unit>3600</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrCubdPerHrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Meter Per Hour Per Second</l-4>
                    </long-name>
                  <display-name>(m^3)/(h*s)</display-name>
                  <factor-si-to-unit>3600</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrCubdPerKiloGr</short-name>
                  <long-name>
                    <l-4 L="EN">Cubic Meter Per Kilogram</l-4>
                    </long-name>
                  <display-name>(m^3)/kg</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len3MNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Meter Per Second</l-4>
                    </long-name>
                  <display-name>m/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrPerSecCubd</short-name>
                  <long-name>
                    <l-4 L="EN">Meter Per Cubic Second</l-4>
                    </long-name>
                  <display-name>m/(s^3)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrPerSecSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Meter Per Square Second</l-4>
                    </long-name>
                  <display-name>m/(s^2)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Square Meter</l-4>
                    </long-name>
                  <display-name>m^2</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>MtrSqdPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Square Meter Per Second</l-4>
                    </long-name>
                  <display-name>(m^2)/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NanoFrd</short-name>
                  <long-name>
                    <l-4 L="EN">Nanofarad</l-4>
                    </long-name>
                  <display-name>nF</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti4I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NanoSec</short-name>
                  <long-name>
                    <l-4 L="EN">Nanosecond</l-4>
                    </long-name>
                  <display-name>ns</display-name>
                  <factor-si-to-unit>1000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NoUnit</short-name>
                  <long-name>
                    <l-4 L="EN">Neither Physical nor Mathematical Unit</l-4>
                    </long-name>
                  <display-name>-</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Nwt</short-name>
                  <long-name>
                    <l-4 L="EN">Newton</l-4>
                    </long-name>
                  <display-name>N</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter</l-4>
                    </long-name>
                  <display-name>Nm</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtrPerRpm</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter Per Rpm</l-4>
                    </long-name>
                  <display-name>Nm/rpm</display-name>
                  <factor-si-to-unit>0.0166666666666667</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtrPerRpmPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter Per Rpm Per Second</l-4>
                    </long-name>
                  <display-name>Nm/(rpm/s)</display-name>
                  <factor-si-to-unit>0.0166666666666667</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter Per Second</l-4>
                    </long-name>
                  <display-name>(N*m)/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtrSec</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter Second</l-4>
                    </long-name>
                  <display-name>Nm*s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtMtrSqrSec</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonmeter Square Second</l-4>
                    </long-name>
                  <display-name>Nm*(s^2)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtPerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Newton Per Meter</l-4>
                    </long-name>
                  <display-name>N/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>NwtSecPerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Newtonsecond Per Meter</l-4>
                    </long-name>
                  <display-name>Ns/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg1_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Ohm</short-name>
                  <long-name>
                    <l-4 L="EN">Ohm</l-4>
                    </long-name>
                  <display-name>Ω</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Pa</short-name>
                  <long-name>
                    <l-4 L="EN">Pascal</l-4>
                    </long-name>
                  <display-name>Pa</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PaPerMtrCubdPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Pascal Per Cubic Meter Per Second</l-4>
                    </long-name>
                  <display-name>Pa/((m^3)/s)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg4M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PaPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Pascal Per Second</l-4>
                    </long-name>
                  <display-name>Pa/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg3</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PaSec</short-name>
                  <long-name>
                    <l-4 L="EN">Pascal Second</l-4>
                    </long-name>
                  <display-name>Pa*s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1M1TiNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PerMille</short-name>
                  <long-name>
                    <l-4 L="EN">Permille</l-4>
                    </long-name>
                  <display-name>‰</display-name>
                  <factor-si-to-unit>1000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PerMin</short-name>
                  <long-name>
                    <l-4 L="EN">Per Minute</l-4>
                    </long-name>
                  <display-name>1/min</display-name>
                  <factor-si-to-unit>60</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Per Meter</l-4>
                    </long-name>
                  <display-name>1/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Per Second</l-4>
                    </long-name>
                  <display-name>1/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PerSecSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Per Square Second</l-4>
                    </long-name>
                  <display-name>1/(s^2)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Perc</short-name>
                  <long-name>
                    <l-4 L="EN">Percent</l-4>
                    </long-name>
                  <display-name>%</display-name>
                  <factor-si-to-unit>100</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PercPerMilliSec</short-name>
                  <long-name>
                    <l-4 L="EN">Percent Per Millisecond</l-4>
                    </long-name>
                  <display-name>%/ms</display-name>
                  <factor-si-to-unit>0.1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PercPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Percent Per Second</l-4>
                    </long-name>
                  <display-name>%/s</display-name>
                  <factor-si-to-unit>100</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PicoFrd</short-name>
                  <long-name>
                    <l-4 L="EN">Picofarad</l-4>
                    </long-name>
                  <display-name>pF</display-name>
                  <factor-si-to-unit>1000000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti4I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>PicoSec</short-name>
                  <long-name>
                    <l-4 L="EN">Picosecond</l-4>
                    </long-name>
                  <display-name>ps</display-name>
                  <factor-si-to-unit>1000000000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Ppm</short-name>
                  <long-name>
                    <l-4 L="EN">Parts Per Million</l-4>
                    </long-name>
                  <display-name>ppm</display-name>
                  <factor-si-to-unit>1000000</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Rad</short-name>
                  <long-name>
                    <l-4 L="EN">Radian</l-4>
                    </long-name>
                  <display-name>rad</display-name>
                  <factor-si-to-unit>6.28318530717958</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">NoDimension_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>RadPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Radian Per Second</l-4>
                    </long-name>
                  <display-name>rad/s</display-name>
                  <factor-si-to-unit>6.28318530717958</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>RadPerSecSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Radian Per Square Second</l-4>
                    </long-name>
                  <display-name>rad/(s^2)</display-name>
                  <factor-si-to-unit>6.28318530717958</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Rpm</short-name>
                  <long-name>
                    <l-4 L="EN">Revolutions Per Minute</l-4>
                    </long-name>
                  <display-name>rpm</display-name>
                  <factor-si-to-unit>60</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg1_2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>RpmPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Revolutions Per Minute Per Second</l-4>
                    </long-name>
                  <display-name>rpm/s</display-name>
                  <factor-si-to-unit>60</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">TiNeg2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>S</short-name>
                  <long-name>
                    <l-4 L="EN">Siemens</l-4>
                    </long-name>
                  <display-name>S</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg2MNeg1Ti3I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>SPerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Siemens Per Meter</l-4>
                    </long-name>
                  <display-name>S/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3MNeg1Ti3I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>SPerMtrPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Siemens Per Meter Per Second</l-4>
                    </long-name>
                  <display-name>S/(m*s)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">LenNeg3MNeg1Ti2I2</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Sec</short-name>
                  <long-name>
                    <l-4 L="EN">Second</l-4>
                    </long-name>
                  <display-name>s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Tesla</short-name>
                  <long-name>
                    <l-4 L="EN">Tesla</l-4>
                    </long-name>
                  <display-name>T</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg2INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Tonne</short-name>
                  <long-name>
                    <l-4 L="EN">Tonne</l-4>
                    </long-name>
                  <display-name>t</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Volt</short-name>
                  <long-name>
                    <l-4 L="EN">Volt</l-4>
                    </long-name>
                  <display-name>V</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>VoltPerMilliSec</short-name>
                  <long-name>
                    <l-4 L="EN">Volt Per Millisecond</l-4>
                    </long-name>
                  <display-name>V/ms</display-name>
                  <factor-si-to-unit>0.001</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg4INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>VoltPerMtr</short-name>
                  <long-name>
                    <l-4 L="EN">Volt Per Meter</l-4>
                    </long-name>
                  <display-name>V/m</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg3INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>VoltPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Volt Per Second</l-4>
                    </long-name>
                  <display-name>V/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg4INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Watt</short-name>
                  <long-name>
                    <l-4 L="EN">Watt</l-4>
                    </long-name>
                  <display-name>W</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg3_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>WattPerKelvinPerMtrSqd</short-name>
                  <long-name>
                    <l-4 L="EN">Watt Per Kelvin Per Square Meter</l-4>
                    </long-name>
                  <display-name>W/(K*m^2)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">M1TiNeg3TNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>WattPerMtrPerKelvin</short-name>
                  <long-name>
                    <l-4 L="EN">Watt Per Meter Per Kelvin</l-4>
                    </long-name>
                  <display-name>W/(m*K)</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len1M1TiNeg3TNeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>WattPerSec</short-name>
                  <long-name>
                    <l-4 L="EN">Watt Per Second</l-4>
                    </long-name>
                  <display-name>W/s</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg4</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>WattSec</short-name>
                  <long-name>
                    <l-4 L="EN">Wattsecond</l-4>
                    </long-name>
                  <display-name>Ws</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2_1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Wb</short-name>
                  <long-name>
                    <l-4 L="EN">Weber</l-4>
                    </long-name>
                  <display-name>Wb</display-name>
                  <factor-si-to-unit>1</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Len2M1TiNeg2INeg1</physical-dimension-ref>
                  </unit>
                <unit>
                  <short-name>Yr</short-name>
                  <long-name>
                    <l-4 L="EN">Year</l-4>
                    </long-name>
                  <display-name>a</display-name>
                  <factor-si-to-unit>3.16880878140289E-08</factor-si-to-unit>
                  <offset-si-to-unit>0</offset-si-to-unit>
                  <physical-dimension-ref DEST="PHYSICAL-DIMENSION" BASE="PhysicalDimensions">Ti1</physical-dimension-ref>
                  </unit>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package>
          <short-name>AUTOSAR_Platform</short-name>
          <ar-packages>
            <ar-package>
              <short-name />
              <short-name>BaseTypes</short-name>
              <category>STANDARD</category>
              <elements>
                <sw-base-type>
                  <short-name>boolean</short-name>
                  <long-name>
                    <l-4 L="EN">boolean</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>8</base-type-size>
                  <base-type-encoding>BOOLEAN</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>float32</short-name>
                  <long-name>
                    <l-4 L="EN">float32</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>32</base-type-size>
                  <base-type-encoding>IEEE754</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>float64</short-name>
                  <long-name>
                    <l-4 L="EN">float64</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>64</base-type-size>
                  <base-type-encoding>IEEE754</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>sint16</short-name>
                  <long-name>
                    <l-4 L="EN">sint16</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>16</base-type-size>
                  <base-type-encoding>2C</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>sint32</short-name>
                  <long-name>
                    <l-4 L="EN">sint32</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>32</base-type-size>
                  <base-type-encoding>2C</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>sint64</short-name>
                  <long-name>
                    <l-4 L="EN">sint64</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>64</base-type-size>
                  <base-type-encoding>2C</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>sint8</short-name>
                  <long-name>
                    <l-4 L="EN">sint8</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>8</base-type-size>
                  <base-type-encoding>2C</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>uint16</short-name>
                  <long-name>
                    <l-4 L="EN">uint16</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>16</base-type-size>
                  <base-type-encoding>NONE</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>uint32</short-name>
                  <long-name>
                    <l-4 L="EN">uint32</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>32</base-type-size>
                  <base-type-encoding>NONE</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>uint64</short-name>
                  <long-name>
                    <l-4 L="EN">uint64</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>64</base-type-size>
                  <base-type-encoding>NONE</base-type-encoding>
                  </sw-base-type>
                <sw-base-type>
                  <short-name>uint8</short-name>
                  <long-name>
                    <l-4 L="EN">uint8</l-4>
                    </long-name>
                  <category>FIXED_LENGTH</category>
                  <base-type-size>8</base-type-size>
                  <base-type-encoding>NONE</base-type-encoding>
                  </sw-base-type>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>CompuMethods</short-name>
              <category>STANDARD</category>
              <elements>
                <compu-method>
                  <short-name>boolean</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0</upper-limit>
                        <compu-const>
                          <vt>FALSE</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">1</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">1</upper-limit>
                        <compu-const>
                          <vt>TRUE</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>DataConstrs</short-name>
              <category>STANDARD</category>
              <elements>
                <data-constr>
                  <short-name>boolean</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>1</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>float32</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-3.40282347e+38</lower-limit>
                        <upper-limit>3.40282347e+38</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>float64</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-1.7976931348623157e+308</lower-limit>
                        <upper-limit>1.7976931348623157e+308</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint16</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-32768</lower-limit>
                        <upper-limit>+32767</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint16_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-32768</lower-limit>
                        <upper-limit>+32767</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint32</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-2147483648</lower-limit>
                        <upper-limit>+2147483647</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint32_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-2147483648</lower-limit>
                        <upper-limit>+2147483647</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint64</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-9223372036854775808</lower-limit>
                        <upper-limit>9223372036854775807</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint8</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-128</lower-limit>
                        <upper-limit>+127</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>sint8_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>-128</lower-limit>
                        <upper-limit>+127</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint16</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>65535</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint16_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>65535</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint32</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>4294967295</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint32_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>4294967295</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint64</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>18446744073709551615</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint8</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>255</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>uint8_least</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>255</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>ImplementationDataTypes</short-name>
              <category>STANDARD</category>
              <elements>
                <implementation-data-type>
                  <short-name>ConstVoidPtr</short-name>
                  <long-name>
                    <l-4 L="EN">ConstVoidPtr</l-4>
                    </long-name>
                  <category>DATA_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-pointer-target-props>
                          <target-category>VALUE</target-category>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_GenDef/BaseTypes/void</base-type-ref>
                                <sw-impl-policy>CONST</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          </sw-pointer-target-props>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>VoidPtr</short-name>
                  <long-name>
                    <l-4 L="EN">VoidPtr</l-4>
                    </long-name>
                  <category>DATA_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-pointer-target-props>
                          <target-category>VALUE</target-category>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_GenDef/BaseTypes/void</base-type-ref>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          </sw-pointer-target-props>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>boolean</short-name>
                  <long-name>
                    <l-4 L="EN">boolean</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/boolean</base-type-ref>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Platform/CompuMethods/boolean</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/boolean</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>float32</short-name>
                  <long-name>
                    <l-4 L="EN">float32</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/float32</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/float32</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>float64</short-name>
                  <long-name>
                    <l-4 L="EN">float64</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/float64</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/float64</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint16</short-name>
                  <long-name>
                    <l-4 L="EN">sint16</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/sint16</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint16</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint16_least</short-name>
                  <long-name>
                    <l-4 L="EN">sint16_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint16_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint32</short-name>
                  <long-name>
                    <l-4 L="EN">sint32</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/sint32</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint32</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint32_least</short-name>
                  <long-name>
                    <l-4 L="EN">sint32_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint32_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint64</short-name>
                  <long-name>
                    <l-4 L="EN">sint64</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/sint64</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint64</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint8</short-name>
                  <long-name>
                    <l-4 L="EN">sint8</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/sint8</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint8</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>sint8_least</short-name>
                  <long-name>
                    <l-4 L="EN">sint8_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/sint8_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint16</short-name>
                  <long-name>
                    <l-4 L="EN">uint16</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/uint16</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint16</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint16_least</short-name>
                  <long-name>
                    <l-4 L="EN">uint16_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint16_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint32</short-name>
                  <long-name>
                    <l-4 L="EN">uint32</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/uint32</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint32</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint32_least</short-name>
                  <long-name>
                    <l-4 L="EN">uint32_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint32_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint64</short-name>
                  <long-name>
                    <l-4 L="EN">uint64</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/uint64</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint64</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint8</short-name>
                  <long-name>
                    <l-4 L="EN">uint8</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/uint8</base-type-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint8</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>uint8_least</short-name>
                  <long-name>
                    <l-4 L="EN">uint8_least</l-4>
                    </long-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Platform/DataConstrs/uint8_least</data-constr-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Platform_Types.h</type-emitter>
                  </implementation-data-type>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>CompuMethods</short-name>
              <category>STANDARD</category>
              <elements>
                <compu-method>
                  <short-name>boolean</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0</upper-limit>
                        <compu-const>
                          <vt>FALSE</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">1</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">1</upper-limit>
                        <compu-const>
                          <vt>TRUE</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package>
          <short-name>AUTOSAR_Std</short-name>
          <ar-packages>
            <ar-package>
              <short-name>BswModuleEntrys</short-name>
              <elements>
                <bsw-module-entry>
                  <short-name>Std_ExtractProtocolHeaderFieldsType</short-name>
                  <sw-service-impl-policy>STANDARD</sw-service-impl-policy>
                  <return-type>
                    <short-name>Std_ReturnType</short-name>
                    <category>TYPE_REFERENCE</category>
                    <sw-data-def-props>
                      <sw-data-def-props-variants>
                        <sw-data-def-props-conditional>
                          <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Std/ImplementationDataTypes/Std_ReturnType</implementation-data-type-ref>
                          </sw-data-def-props-conditional>
                        </sw-data-def-props-variants>
                      </sw-data-def-props>
                    </return-type>
                  <arguments>
                    <sw-service-arg>
                      <short-name>buffer</short-name>
                      <category>DATA_REFERENCE</category>
                      <direction>IN</direction>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-pointer-target-props>
                              <target-category>TYPE_REFERENCE</target-category>
                              <sw-data-def-props>
                                <sw-data-def-props-variants>
                                  <sw-data-def-props-conditional>
                                    <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                                    <sw-impl-policy>CONST</sw-impl-policy>
                                    </sw-data-def-props-conditional>
                                  </sw-data-def-props-variants>
                                </sw-data-def-props>
                              </sw-pointer-target-props>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </sw-service-arg>
                    <sw-service-arg>
                      <short-name>bufferLength</short-name>
                      <category>TYPE_REFERENCE</category>
                      <direction>IN</direction>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </sw-service-arg>
                    <sw-service-arg>
                      <short-name>messageType</short-name>
                      <category>DATA_REFERENCE</category>
                      <direction>OUT</direction>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-pointer-target-props>
                              <target-category>TYPE_REFERENCE</target-category>
                              <sw-data-def-props>
                                <sw-data-def-props-variants>
                                  <sw-data-def-props-conditional>
                                    <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Std/ImplementationDataTypes/Std_MessageTypeType</implementation-data-type-ref>
                                    </sw-data-def-props-conditional>
                                  </sw-data-def-props-variants>
                                </sw-data-def-props>
                              </sw-pointer-target-props>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </sw-service-arg>
                    <sw-service-arg>
                      <short-name>messageResult</short-name>
                      <category>DATA_REFERENCE</category>
                      <direction>OUT</direction>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-pointer-target-props>
                              <target-category>TYPE_REFERENCE</target-category>
                              <sw-data-def-props>
                                <sw-data-def-props-variants>
                                  <sw-data-def-props-conditional>
                                    <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Std/ImplementationDataTypes/Std_MessageResultType</implementation-data-type-ref>
                                    </sw-data-def-props-conditional>
                                  </sw-data-def-props-variants>
                                </sw-data-def-props>
                              </sw-pointer-target-props>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </sw-service-arg>
                    </arguments>
                  </bsw-module-entry>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>CompuMethods</short-name>
              <category>STANDARD</category>
              <elements>
                <compu-method>
                  <short-name>Std_MessageResultType</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x00</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x00</upper-limit>
                        <compu-const>
                          <vt>STD_MESSAGERESULT_OK</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x01</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x01</upper-limit>
                        <compu-const>
                          <vt>STD_MESSAGERESULT_ERROR</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                <compu-method>
                  <short-name>Std_MessageTypeType</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x00</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x00</upper-limit>
                        <compu-const>
                          <vt>STD_MESSAGETYPE_REQUEST</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x01</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x01</upper-limit>
                        <compu-const>
                          <vt>STD_MESSAGETYPE_RESPONSE</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                <compu-method>
                  <short-name>Std_ReturnType</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0</upper-limit>
                        <compu-const>
                          <vt>E_OK</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">1</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">1</upper-limit>
                        <compu-const>
                          <vt>E_NOT_OK</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                <compu-method>
                  <short-name>Std_TransformerClass</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x00</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x00</upper-limit>
                        <compu-const>
                          <vt>STD_TRANSFORMER_UNSPECIFIED</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x01</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x01</upper-limit>
                        <compu-const>
                          <vt>STD_TRANSFORMER_SERIALIZER</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x02</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x02</upper-limit>
                        <compu-const>
                          <vt>STD_TRANSFORMER_SAFETY</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x03</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x03</upper-limit>
                        <compu-const>
                          <vt>STD_TRANSFORMER_SECURITY</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0xFF</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0xFF</upper-limit>
                        <compu-const>
                          <vt>STD_TRANSFORMER_CUSTOM</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                <compu-method>
                  <short-name>Std_TransformerForwardCode</short-name>
                  <category>TEXTTABLE</category>
                  <compu-internal-to-phys>
                    <compu-scales>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x00</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x00</upper-limit>
                        <compu-const>
                          <vt>E_OK</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x01</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x01</upper-limit>
                        <compu-const>
                          <vt>E_SAFETY_INVALID_REP</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x02</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x02</upper-limit>
                        <compu-const>
                          <vt>E_SAFETY_INVALID_SEQ</vt>
                          </compu-const>
                        </compu-scale>
                      <compu-scale>
                        <lower-limit INTERVAL-TYPE="CLOSED">0x03</lower-limit>
                        <upper-limit INTERVAL-TYPE="CLOSED">0x03</upper-limit>
                        <compu-const>
                          <vt>E_SAFETY_INVALID_CRC</vt>
                          </compu-const>
                        </compu-scale>
                      </compu-scales>
                    </compu-internal-to-phys>
                  </compu-method>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>DataConstrs</short-name>
              <category>STANDARD</category>
              <elements>
                <data-constr>
                  <short-name>Std_MessageResultType</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0x00</lower-limit>
                        <upper-limit>0x02</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>Std_MessageTypeType</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0x00</lower-limit>
                        <upper-limit>0x02</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>Std_ReturnType</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0</lower-limit>
                        <upper-limit>1</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>Std_TransformerClass</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0x00</lower-limit>
                        <upper-limit>0xFF</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>Std_TransformerErrorCode</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0x00</lower-limit>
                        <upper-limit>0xFF</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                <data-constr>
                  <short-name>Std_TransformerForwardCode</short-name>
                  <data-constr-rules>
                    <data-constr-rule>
                      <internal-constrs>
                        <lower-limit>0x00</lower-limit>
                        <upper-limit>0x03</upper-limit>
                        </internal-constrs>
                      </data-constr-rule>
                    </data-constr-rules>
                  </data-constr>
                </elements>
              </ar-package>
            <ar-package>
              <short-name>ImplementationDataTypes</short-name>
              <category>STANDARD</category>
              <elements>
                <implementation-data-type>
                  <short-name>Std_ExtractProtocolHeaderFieldsType</short-name>
                  <desc>
                    <l-2 L="EN">Type for the function pointer to extract the relevant protocol header fields of the message and the type of the message result of a transformer. - At the time being, this is limited to the types used for C/S communication (i.e., REQUEST and RESPONSE and OK and ERROR).</l-2>
                    </desc>
                  <category>FUNCTION_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-pointer-target-props>
                          <target-category>FUNCTION_REFERENCE</target-category>
                          <function-pointer-signature-ref DEST="BSW-MODULE-ENTRY">/AUTOSAR/AUTOSAR_Std/BswModuleEntrys/Std_ExtractProtocolHeaderFieldsType</function-pointer-signature-ref>
                          </sw-pointer-target-props>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_MessageResultType</short-name>
                  <desc>
                    <l-2 L="EN">This type is used to encode different types of results for response messages. - Currently this encoding is limited to the distinction between OK and ERROR responses.</l-2>
                    </desc>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Std/CompuMethods/Std_MessageResultType</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_MessageResultType</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_MessageTypeType</short-name>
                  <desc>
                    <l-2 L="EN">This type is used to encode the different type of messages. - Currently this encoding is limited to the distinction between requests and responses in C/S communication.</l-2>
                    </desc>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Std/CompuMethods/Std_MessageTypeType</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_MessageTypeType</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_ReturnType</short-name>
                  <desc>
                    <l-2 L="EN">This type can be used as standard API return type which is shared between the RTE and the BSW modules. It shall be defined as follows: typedef uint8 Std_ReturnType;</l-2>
                    </desc>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Std/CompuMethods/Std_ReturnType</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_ReturnType</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_TransformerClass</short-name>
                  <desc>
                    <l-2 L="EN">Std_TransformerClass is an enumeration where each element represents a transformer class.</l-2>
                    </desc>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Std/CompuMethods/Std_TransformerClass</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_TransformerClass</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_TransformerError</short-name>
                  <category>STRUCTURE</category>
                  <sub-elements>
                    <implementation-data-type-element>
                      <short-name>errorCode</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Std/ImplementationDataTypes/Std_TransformerErrorCode</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    <implementation-data-type-element>
                      <short-name>transformerClass</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Std/ImplementationDataTypes/Std_TransformerClass</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    </sub-elements>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_TransformerErrorCode</short-name>
                  <desc>
                    <l-2 L="EN">The type of the Std_TransformerError.</l-2>
                    </desc>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_TransformerErrorCode</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_TransformerForwardCode</short-name>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <compu-method-ref DEST="COMPU-METHOD">/AUTOSAR/AUTOSAR_Std/CompuMethods/Std_TransformerForwardCode</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/AUTOSAR/AUTOSAR_Std/DataConstrs/Std_TransformerForwardCode</data-constr-ref>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                <implementation-data-type>
                  <short-name>Std_VersionInfoType</short-name>
                  <desc>
                    <l-2 L="EN">This type shall be used to request the version of a BSW module using the &lt;Module name&gt;_GetVersionInfo() function.</l-2>
                    </desc>
                  <category>STRUCTURE</category>
                  <sub-elements>
                    <implementation-data-type-element>
                      <short-name>vendorID</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    <implementation-data-type-element>
                      <short-name>moduleID</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    <implementation-data-type-element>
                      <short-name>sw_major_version</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    <implementation-data-type-element>
                      <short-name>sw_minor_version</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    <implementation-data-type-element>
                      <short-name>sw_patch_version</short-name>
                      <category>TYPE_REFERENCE</category>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    </sub-elements>
                  <type-emitter>Std_Types.h</type-emitter>
                  </implementation-data-type>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        </ar-packages>
      </ar-package>
    <ar-package>
      <short-name>Communication</short-name>
      <ar-packages>
        <ar-package>
          <short-name>CommunicationClusters</short-name>
          </ar-package>
        <ar-package>
          <short-name>Frames</short-name>
          </ar-package>
        <ar-package>
          <short-name>ISignals</short-name>
          </ar-package>
        <ar-package>
          <short-name>Pdus</short-name>
          </ar-package>
        <ar-package>
          <short-name>SystemSignals</short-name>
          </ar-package>
        </ar-packages>
      </ar-package>
    <ar-package>
      <short-name>EcuInstances</short-name>
      </ar-package>
    <ar-package UUID="9ae99405-7be6-41c0-ad56-a5fa909a1e5c">
      <short-name>RootSWComposition</short-name>
      </ar-package>
    <ar-package>
      <short-name>SharedElements</short-name>
      <ar-packages>
        <ar-package>
          <short-name>ApplicationDataTypes</short-name>
          <ar-packages>
            <ar-package UUID="035a8ab9-015a-426c-8766-e4b58e5c5a98">
              <short-name>Array</short-name>
              <elements>
                <application-array-data-type UUID="99540e2c-05ec-4a85-94bb-9a3999ac57fe">
                  <short-name>ApplicationArrayDataType_Fixed</short-name>
                  <category>ARRAY</category>
                  <element UUID="7391c5fe-50b6-4b88-bc63-ec1975221a4f">
                    <short-name>Element</short-name>
                    <category>VALUE</category>
                    <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                    <array-size-semantics>FIXED-SIZE</array-size-semantics>
                    <max-number-of-elements>15</max-number-of-elements>
                    </element>
                  </application-array-data-type>
                <application-array-data-type UUID="d5f3c7e9-dd94-4d37-888e-b6e44b01cc5a">
                  <short-name>ApplicationArrayDataType_Variable</short-name>
                  <category>ARRAY</category>
                  <element UUID="fef3f4b8-d9bd-4cb1-94b8-4403e665c4fa">
                    <short-name>Element</short-name>
                    <category>VALUE</category>
                    <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                    <array-size-semantics>VARIABLE-SIZE</array-size-semantics>
                    <max-number-of-elements>15</max-number-of-elements>
                    </element>
                  </application-array-data-type>
                </elements>
              </ar-package>
            <ar-package UUID="b142aaa0-2671-41cd-bbc6-78cc30cf22c4">
              <short-name>Primitive</short-name>
              <elements>
                <application-primitive-data-type UUID="18357165-e774-4282-90db-fcb76c7c6727">
                  <short-name>ApplicationPrimitiveDataType</short-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-calibration-access>NOT-ACCESSIBLE</sw-calibration-access>
                        <compu-method-ref DEST="COMPU-METHOD">/SharedElements/CompuMethods/CompuMethod</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/SharedElements/DataConstr/DataConstr</data-constr-ref>
                        <invalid-value>
                          <application-value-specification>
                            <category>VALUE</category>
                            <sw-value-cont>
                              <sw-values-phys>
                                <v>8</v>
                                </sw-values-phys>
                              </sw-value-cont>
                            </application-value-specification>
                          </invalid-value>
                        <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </application-primitive-data-type>
                <application-primitive-data-type UUID="14c56edb-9cf8-48cc-92d7-4cc1ca683a0f">
                  <short-name>Bool_ApplicationPrimitiveDataType</short-name>
                  <category>BOOLEAN</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-calibration-access>NOT-ACCESSIBLE</sw-calibration-access>
                        <compu-method-ref DEST="COMPU-METHOD">/SharedElements/CompuMethods/CompuMethod</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/SharedElements/DataConstr/DataConstr</data-constr-ref>
                        <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </application-primitive-data-type>
                <application-primitive-data-type UUID="a799e394-8020-4e26-abaf-804ce312d6c0">
                  <short-name>Copy_ApplicationPrimitiveDataType</short-name>
                  <category>VALUE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-calibration-access>NOT-ACCESSIBLE</sw-calibration-access>
                        <compu-method-ref DEST="COMPU-METHOD">/SharedElements/CompuMethods/CompuMethod</compu-method-ref>
                        <data-constr-ref DEST="DATA-CONSTR">/SharedElements/DataConstr/DataConstr</data-constr-ref>
                        <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </application-primitive-data-type>
                <application-primitive-data-type UUID="decc899e-e751-4907-998b-8769b6445a38">
                  <short-name>String_ApplicationPrimitiveDataType</short-name>
                  <category>STRING</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <sw-calibration-access>NOT-ACCESSIBLE</sw-calibration-access>
                        <sw-text-props>
                          <array-size-semantics>VARIABLE-SIZE</array-size-semantics>
                          <sw-max-text-size>16</sw-max-text-size>
                          </sw-text-props>
                        <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </application-primitive-data-type>
                </elements>
              </ar-package>
            <ar-package UUID="65217d8d-3662-4a20-a643-ec9ee94de7a0">
              <short-name>Record</short-name>
              <elements>
                <application-record-data-type UUID="d20b1ec6-9940-43c7-beda-f773a805fab6">
                  <short-name>ApplicationRecordDataType</short-name>
                  <category>STRUCTURE</category>
                  <elements>
                    <application-record-element UUID="bd5079b0-6ac0-4d72-a63a-afd373f2bcc5">
                      <short-name>Element</short-name>
                      <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                      </application-record-element>
                    <application-record-element UUID="12021f0e-9ad1-4df2-bffa-197611387a0a">
                      <short-name>Element1</short-name>
                      <type-tref DEST="APPLICATION-ARRAY-DATA-TYPE">/SharedElements/ApplicationDataTypes/Array/ApplicationArrayDataType_Fixed</type-tref>
                      </application-record-element>
                    </elements>
                  </application-record-data-type>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package>
          <short-name>CompuMethods</short-name>
          <elements>
            <compu-method UUID="e51fd87b-fe38-48d5-b94a-c11851da3006">
              <short-name>BITFIELD_TEXTTABLE_CompuMethod</short-name>
              <category>BITFIELD_TEXTTABLE</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <mask>0</mask>
                    <lower-limit>0</lower-limit>
                    <upper-limit>0</upper-limit>
                    <compu-const>
                      <vt>xyz</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <mask>0</mask>
                    <lower-limit>1</lower-limit>
                    <upper-limit>1</upper-limit>
                    <compu-const>
                      <vt>xyz1</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <mask>0</mask>
                    <lower-limit>2</lower-limit>
                    <upper-limit>2</upper-limit>
                    <compu-const>
                      <vt>xyz2</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <mask>0</mask>
                    <lower-limit>3</lower-limit>
                    <upper-limit>3</upper-limit>
                    <compu-const>
                      <vt>xyz3</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <mask>0</mask>
                    <lower-limit>4</lower-limit>
                    <upper-limit>4</upper-limit>
                    <compu-const>
                      <vt>xyz4</vt>
                      </compu-const>
                    </compu-scale>
                  </compu-scales>
                </compu-internal-to-phys>
              </compu-method>
            <compu-method UUID="74ea35c5-6b05-40a2-b22c-3c1a179a095b">
              <short-name>RAT_FUNC_CompuMethod</short-name>
              <category>RAT_FUNC</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <compu-rational-coeffs>
                      <compu-numerator>
                        <v>0</v>
                        <v>1</v>
                        <v>0</v>
                        </compu-numerator>
                      <compu-denominator>
                        <v>1</v>
                        <v>0</v>
                        <v>0</v>
                        </compu-denominator>
                      </compu-rational-coeffs>
                    </compu-scale>
                  </compu-scales>
                </compu-internal-to-phys>
              </compu-method>
            <compu-method UUID="cb57246c-cf48-448f-b8a5-5f319b76ee49">
              <short-name>SCALE_RATIONAL_AND_TEXTTABLE_CompuMethod</short-name>
              <desc>
                <l-2 L="FOR-ALL">S</l-2>
                </desc>
              <category>SCALE_RATIONAL_AND_TEXTTABLE</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <lower-limit>0</lower-limit>
                    <upper-limit>15</upper-limit>
                    <compu-rational-coeffs>
                      <compu-numerator>
                        <v>0</v>
                        <v>1</v>
                        <v>0</v>
                        </compu-numerator>
                      <compu-denominator>
                        <v>1</v>
                        <v>0</v>
                        <v>0</v>
                        </compu-denominator>
                      </compu-rational-coeffs>
                    </compu-scale>
                  <compu-scale>
                    <symbol>sdcd</symbol>
                    <lower-limit>16</lower-limit>
                    <upper-limit>16</upper-limit>
                    <compu-const>
                      <vt>sdcd</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <symbol>sdcd1</symbol>
                    <lower-limit>17</lower-limit>
                    <upper-limit>17</upper-limit>
                    <compu-const>
                      <vt>sdcd1</vt>
                      </compu-const>
                    </compu-scale>
                  </compu-scales>
                <compu-default-value>
                  <v>17</v>
                  </compu-default-value>
                </compu-internal-to-phys>
              </compu-method>
            <compu-method UUID="19ee54ef-4447-4987-bcbe-a9d2a743d569">
              <short-name>Scale_linear_And_texttable_CompuMethod</short-name>
              <desc>
                <l-2 L="FOR-ALL">Scale_linear _And_texttable_CompuMethod</l-2>
                </desc>
              <category>SCALE_LINEAR_AND_TEXTTABLE</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <lower-limit>0</lower-limit>
                    <upper-limit>7</upper-limit>
                    <compu-rational-coeffs>
                      <compu-numerator>
                        <v>0</v>
                        <v>1</v>
                        </compu-numerator>
                      <compu-denominator>
                        <v>1</v>
                        </compu-denominator>
                      </compu-rational-coeffs>
                    </compu-scale>
                  <compu-scale>
                    <symbol>abcd</symbol>
                    <lower-limit>8</lower-limit>
                    <upper-limit>8</upper-limit>
                    <compu-const>
                      <vt>abcd</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <symbol>abcd1</symbol>
                    <lower-limit>9</lower-limit>
                    <upper-limit>9</upper-limit>
                    <compu-const>
                      <vt>abcd1</vt>
                      </compu-const>
                    </compu-scale>
                  </compu-scales>
                <compu-default-value>
                  <v>8</v>
                  </compu-default-value>
                </compu-internal-to-phys>
              </compu-method>
            <compu-method UUID="d4a62613-2238-4523-b274-2677c5a2235a">
              <short-name>TAB_NOINTP_CompuMethod</short-name>
              <desc />
              <category>TAB_NOINTP</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <desc>
                      <l-2 L="AA" />
                      </desc>
                    <lower-limit>0</lower-limit>
                    <upper-limit>0</upper-limit>
                    <compu-const>
                      <v>10</v>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <lower-limit>1</lower-limit>
                    <upper-limit>1</upper-limit>
                    <compu-const>
                      <v>9</v>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <lower-limit>2</lower-limit>
                    <upper-limit>2</upper-limit>
                    <compu-const>
                      <v>8</v>
                      </compu-const>
                    </compu-scale>
                  </compu-scales>
                <compu-default-value>
                  <vf>0</vf>
                  </compu-default-value>
                </compu-internal-to-phys>
              </compu-method>
            <compu-method UUID="6ef51214-688c-4e48-a115-d80fcf62bffc">
              <short-name>TEXTTABLE_CompuMethod</short-name>
              <category>TEXTTABLE</category>
              <unit-ref DEST="UNIT">/AUTOSAR/AUTOSAR_PhysicalUnits/Units/NoUnit</unit-ref>
              <compu-internal-to-phys>
                <compu-scales>
                  <compu-scale>
                    <symbol>text1</symbol>
                    <lower-limit>0</lower-limit>
                    <upper-limit>0</upper-limit>
                    <compu-const>
                      <vt>text1</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <symbol>text2</symbol>
                    <lower-limit>1</lower-limit>
                    <upper-limit>1</upper-limit>
                    <compu-const>
                      <vt>text2</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <symbol>text3</symbol>
                    <lower-limit>2</lower-limit>
                    <upper-limit>2</upper-limit>
                    <compu-const>
                      <vt>text3</vt>
                      </compu-const>
                    </compu-scale>
                  <compu-scale>
                    <symbol>text4</symbol>
                    <lower-limit>3</lower-limit>
                    <upper-limit>3</upper-limit>
                    <compu-const>
                      <vt>text4</vt>
                      </compu-const>
                    </compu-scale>
                  </compu-scales>
                <compu-default-value>
                  <v>0</v>
                  </compu-default-value>
                </compu-internal-to-phys>
              </compu-method>
            </elements>
          </ar-package>
        <ar-package>
          <short-name>ConstantSpecifications</short-name>
          <elements>
            <constant-specification UUID="5679b253-a22a-4532-8116-7ce8ac35a562">
              <short-name>ApplicationSwComponentType_ExplicitInterRunnableVariable</short-name>
              <value-spec>
                <numerical-value-specification>
                  <short-label>Value</short-label>
                  <value>0</value>
                  </numerical-value-specification>
                </value-spec>
              </constant-specification>
            <constant-specification UUID="82a61fa2-2547-4ce8-a0d4-c583629db923">
              <short-name>ApplicationSwComponentType_SharedParameter</short-name>
              <value-spec>
                <numerical-value-specification>
                  <short-label>Value</short-label>
                  <value>5.5</value>
                  </numerical-value-specification>
                </value-spec>
              </constant-specification>
            <constant-specification UUID="e3a2b67f-9cda-465d-8b6f-f31127e7b3a1">
              <short-name>ApplicationSwComponentType_StaticMemory</short-name>
              <value-spec>
                <numerical-value-specification>
                  <short-label>Value</short-label>
                  <value>9</value>
                  </numerical-value-specification>
                </value-spec>
              </constant-specification>
            <constant-specification UUID="3c303401-cc30-49f7-a7cb-0cf2844a3f18">
              <short-name>ConstantSpecification</short-name>
              </constant-specification>
            </elements>
          </ar-package>
        <ar-package UUID="6fcb326d-7f82-4cd3-9429-fa90f212d1e8">
          <short-name>ConstantTypeMappingSets</short-name>
          <elements>
            <constant-specification-mapping-set UUID="4f3bdbd1-af02-46e6-a3ba-411118807380">
              <short-name>ConstantSpecificationMappingSet</short-name>
              </constant-specification-mapping-set>
            </elements>
          </ar-package>
        <ar-package UUID="5b7c99d1-d4ef-481b-95e4-0d6975de4f3b">
          <short-name>DataConstr</short-name>
          <elements>
            <data-constr UUID="78b9384e-7f45-4396-b617-a03a03aaf3ce">
              <short-name>DataConstr</short-name>
              <data-constr-rules>
                <data-constr-rule>
                  <constr-level>0</constr-level>
                  <phys-constrs>
                    <lower-limit>0</lower-limit>
                    <upper-limit>7</upper-limit>
                    </phys-constrs>
                  </data-constr-rule>
                </data-constr-rules>
              </data-constr>
            </elements>
          </ar-package>
        <ar-package UUID="463cbb86-4f8e-463e-8bb3-dafc528ccbdf">
          <short-name>DataTypemappingSets</short-name>
          <elements>
            <data-type-mapping-set UUID="84bab728-8c47-495c-a5d4-5290c3551358">
              <short-name>DataTypeMappingSet</short-name>
              <data-type-maps>
                <data-type-map>
                  <application-data-type-ref DEST="APPLICATION-ARRAY-DATA-TYPE">/SharedElements/ApplicationDataTypes/Array/ApplicationArrayDataType_Fixed</application-data-type-ref>
                  <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/SharedElements/ImplementationDataTypes/ARRAY_ImplementationDataType</implementation-data-type-ref>
                  </data-type-map>
                <data-type-map>
                  <application-data-type-ref DEST="APPLICATION-RECORD-DATA-TYPE">/SharedElements/ApplicationDataTypes/Record/ApplicationRecordDataType</application-data-type-ref>
                  <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/SharedElements/ImplementationDataTypes/STRUCTURE_ImplementationDataType1</implementation-data-type-ref>
                  </data-type-map>
                <data-type-map>
                  <application-data-type-ref DEST="APPLICATION-ARRAY-DATA-TYPE">/SharedElements/ApplicationDataTypes/Array/ApplicationArrayDataType_Variable</application-data-type-ref>
                  <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/SharedElements/ImplementationDataTypes/Struct_Array_ImplementationDataType</implementation-data-type-ref>
                  </data-type-map>
                <data-type-map>
                  <application-data-type-ref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</application-data-type-ref>
                  <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                  </data-type-map>
                </data-type-maps>
              </data-type-mapping-set>
            </elements>
          </ar-package>
        <ar-package>
          <short-name>ImplementationDataTypes</short-name>
          <elements>
            <implementation-data-type UUID="21f9a013-317d-4a6a-8c1d-cdc72f7df8f5">
              <short-name>ARRAY_ImplementationDataType</short-name>
              <category>ARRAY</category>
              <sw-data-def-props>
                <sw-data-def-props-variants>
                  <sw-data-def-props-conditional />
                  </sw-data-def-props-variants>
                </sw-data-def-props>
              <sub-elements>
                <implementation-data-type-element UUID="5512b8b7-a43f-436f-bb18-47a903ad1e17">
                  <short-name>SubElement</short-name>
                  <category>TYPE_REFERENCE</category>
                  <array-size>15</array-size>
                  <array-size-semantics>FIXED-SIZE</array-size-semantics>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                </sub-elements>
              </implementation-data-type>
            <implementation-data-type UUID="f01098ff-1c78-439e-9476-11d641870637">
              <short-name>ARRAY_ImplementationDataType1</short-name>
              <category>ARRAY</category>
              <sub-elements>
                <implementation-data-type-element UUID="ee36cc86-25eb-4048-8698-d1ec326fda32">
                  <short-name>SubElement</short-name>
                  <category>TYPE_REFERENCE</category>
                  <array-size>15</array-size>
                  <array-size-semantics>VARIABLE-SIZE</array-size-semantics>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/SharedElements/ImplementationDataTypes/STRUCTURE_ImplementationDataType1</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                </sub-elements>
              </implementation-data-type>
            <implementation-data-type UUID="77ef0bea-be4b-4dea-b5ea-114e5a3f3d26">
              <short-name>ImplementationDataType</short-name>
              <category>VALUE</category>
              <sw-data-def-props>
                <sw-data-def-props-variants>
                  <sw-data-def-props-conditional>
                    <base-type-ref DEST="SW-BASE-TYPE">/AUTOSAR/AUTOSAR_Platform/BaseTypes/uint8</base-type-ref>
                    </sw-data-def-props-conditional>
                  </sw-data-def-props-variants>
                </sw-data-def-props>
              </implementation-data-type>
            <implementation-data-type UUID="53ec3bfc-5a92-4d42-b31b-8e29e99a2b46">
              <short-name>STRUCTURE_ImplementationDataType1</short-name>
              <category>STRUCTURE</category>
              <sub-elements>
                <implementation-data-type-element UUID="31f01782-3ce8-4dbe-81d1-0d5fb89bef99">
                  <short-name>SubElement</short-name>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                <implementation-data-type-element UUID="83bd06cb-a4ff-4d55-bd3d-1a691b582d46">
                  <short-name>SubElement1</short-name>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/SharedElements/ImplementationDataTypes/ARRAY_ImplementationDataType</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                </sub-elements>
              </implementation-data-type>
            <implementation-data-type UUID="ccd15817-26a8-424d-8c87-3f3d70b5ee9d">
              <short-name>Struct_Array_ImplementationDataType</short-name>
              <category>STRUCTURE</category>
              <sub-elements>
                <implementation-data-type-element UUID="3f61bc0d-d829-4ab0-9e22-7de6a25972e3">
                  <short-name>SubElement1</short-name>
                  <category>TYPE_REFERENCE</category>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional>
                        <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</implementation-data-type-ref>
                        </sw-data-def-props-conditional>
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                <implementation-data-type-element UUID="dc530c9c-3b65-4707-99c3-842e2d2b7788">
                  <short-name>SubElement</short-name>
                  <category>ARRAY</category>
                  <sub-elements>
                    <implementation-data-type-element UUID="af21d788-9aea-4789-b7d0-8665f2d0c8c7">
                      <short-name>SubElement</short-name>
                      <category>TYPE_REFERENCE</category>
                      <array-size>15</array-size>
                      <array-size-semantics>VARIABLE-SIZE</array-size-semantics>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint16</implementation-data-type-ref>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      </implementation-data-type-element>
                    </sub-elements>
                  <sw-data-def-props>
                    <sw-data-def-props-variants>
                      <sw-data-def-props-conditional />
                      </sw-data-def-props-variants>
                    </sw-data-def-props>
                  </implementation-data-type-element>
                </sub-elements>
              </implementation-data-type>
            <implementation-data-type UUID="79fa9e8f-a805-43da-b4b5-ac42d2a23ff0">
              <short-name>TypeTref_ImplementationDataType</short-name>
              <category>TYPE_REFERENCE</category>
              <sw-data-def-props>
                <sw-data-def-props-variants>
                  <sw-data-def-props-conditional>
                    <implementation-data-type-ref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/float32</implementation-data-type-ref>
                    </sw-data-def-props-conditional>
                  </sw-data-def-props-variants>
                </sw-data-def-props>
              </implementation-data-type>
            </elements>
          </ar-package>
        <ar-package>
          <short-name>PortInterfaces</short-name>
          <ar-packages>
            <ar-package UUID="a0d0a13a-15e8-47a3-8169-5f11ad6c7d3f">
              <short-name>ClientServer</short-name>
              <elements>
                <client-server-interface UUID="de068aa3-6af8-4bad-a17f-893dbfa6d08d">
                  <short-name>ClientServerInterface</short-name>
                  <is-service>false</is-service>
                  <operations>
                    <client-server-operation UUID="f963f5c2-07f7-439d-be71-e8ffb77736cb">
                      <short-name>Operation</short-name>
                      <arguments>
                        <argument-data-prototype UUID="0757643f-ef26-4951-9974-c0ad09b5c8d0">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                          <direction>IN</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    <client-server-operation UUID="9d946ffc-e827-4a3b-9217-80ae67bdce09">
                      <short-name>Operation1</short-name>
                      <arguments>
                        <argument-data-prototype UUID="fbd7c03a-e379-467c-9efb-5818113f5e64">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                          <direction>OUT</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    </operations>
                  </client-server-interface>
                <client-server-interface UUID="68861440-758d-43f6-92a2-fed7438de313">
                  <short-name>Copy2_ClientServerInterface</short-name>
                  <is-service>false</is-service>
                  <operations>
                    <client-server-operation UUID="dd8cf435-bddb-45bb-a59d-cffcdd11cedd">
                      <short-name>Operation</short-name>
                      <arguments>
                        <argument-data-prototype UUID="474b5949-0760-4780-9d06-6d2b549c40e3">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                          <direction>IN</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    <client-server-operation UUID="ceba0008-a280-4915-acc8-c4b28afc10c4">
                      <short-name>Operation1</short-name>
                      <arguments>
                        <argument-data-prototype UUID="48e7b87f-8674-441c-bc3e-b6143e20802e">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                          <direction>OUT</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    </operations>
                  </client-server-interface>
                <client-server-interface UUID="9b8ada7b-e7a9-49d6-a945-db726b3bd1f9">
                  <short-name>Copy3_ClientServerInterface</short-name>
                  <is-service>false</is-service>
                  <operations>
                    <client-server-operation UUID="8b64e196-a577-4332-a8f2-8e907214f2ac">
                      <short-name>Operation</short-name>
                      <arguments>
                        <argument-data-prototype UUID="cf106dae-c79b-4cea-a011-2d5ff268ac3e">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                          <direction>IN</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    <client-server-operation UUID="03f0b7d8-222c-465d-9663-185446b9f092">
                      <short-name>Operation1</short-name>
                      <arguments>
                        <argument-data-prototype UUID="9fe53cee-82db-4c74-887a-137d3260eae6">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                          <direction>OUT</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    </operations>
                  </client-server-interface>
                <client-server-interface UUID="bc94762b-35e3-49e1-ae8b-70bc63394d9c">
                  <short-name>Copy4_ClientServerInterface</short-name>
                  <is-service>false</is-service>
                  <operations>
                    <client-server-operation UUID="4f953ec5-5e57-4a1c-bcf2-9eba8fde4ddd">
                      <short-name>Operation</short-name>
                      <arguments>
                        <argument-data-prototype UUID="573e55c4-304e-48a7-ae98-47c7744d4415">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                          <direction>IN</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    <client-server-operation UUID="32dd33c4-e167-4858-93d3-bc02d325d12c">
                      <short-name>Operation1</short-name>
                      <arguments>
                        <argument-data-prototype UUID="28cc5664-0a70-4275-b1a3-3cb7a40597db">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                          <direction>OUT</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    </operations>
                  </client-server-interface>
                <client-server-interface UUID="ad797ff8-41de-49b7-a6c3-c2dd864f60dd">
                  <short-name>Copy_ClientServerInterface</short-name>
                  <is-service>false</is-service>
                  <operations>
                    <client-server-operation UUID="5d536ac2-edd2-4788-b233-5b0ef32a2022">
                      <short-name>Operation</short-name>
                      <arguments>
                        <argument-data-prototype UUID="174674f0-498e-41bc-9667-2459277f62ea">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                          <direction>IN</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    <client-server-operation UUID="be00c41e-3412-411d-ad74-a6a0feee0ecd">
                      <short-name>Operation1</short-name>
                      <arguments>
                        <argument-data-prototype UUID="8c68ce17-1680-4ec1-951d-9d9c871aca06">
                          <short-name>Argument</short-name>
                          <sw-data-def-props>
                            <sw-data-def-props-variants>
                              <sw-data-def-props-conditional>
                                <sw-impl-policy>STANDARD</sw-impl-policy>
                                </sw-data-def-props-conditional>
                              </sw-data-def-props-variants>
                            </sw-data-def-props>
                          <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                          <direction>OUT</direction>
                          <server-argument-impl-policy>USE-ARGUMENT-TYPE</server-argument-impl-policy>
                          </argument-data-prototype>
                        </arguments>
                      </client-server-operation>
                    </operations>
                  </client-server-interface>
                </elements>
              </ar-package>
            <ar-package UUID="3503a605-12c8-44be-96cf-4ad548d5d58f">
              <short-name>ModeSwitch</short-name>
              <elements>
                <mode-declaration-group UUID="d1db93d0-7154-468f-b3bc-872d23a7385f">
                  <short-name>Copy_ModeDeclarationGroup</short-name>
                  <category>EXPLICIT_ORDER</category>
                  <initial-mode-ref DEST="MODE-DECLARATION">/SharedElements/PortInterfaces/ModeSwitch/Copy_ModeDeclarationGroup/ModeDeclaration</initial-mode-ref>
                  <mode-declarations>
                    <mode-declaration UUID="2608f59c-87b0-47b2-8cee-8e9c3ba94cac">
                      <short-name>ModeDeclaration</short-name>
                      <value>0</value>
                      </mode-declaration>
                    <mode-declaration UUID="7cc2e588-342f-40a3-ad77-b3d49457e996">
                      <short-name>ModeDeclaration1</short-name>
                      <value>1</value>
                      </mode-declaration>
                    <mode-declaration UUID="278335ee-b40e-4f50-9fc3-164297dafbfd">
                      <short-name>ModeDeclaration2</short-name>
                      <value>2</value>
                      </mode-declaration>
                    </mode-declarations>
                  <on-transition-value>3</on-transition-value>
                  </mode-declaration-group>
                <mode-switch-interface UUID="359238c5-e830-44a4-b8a0-362c11b6864f">
                  <short-name>Copy_ModeSwitchInterface</short-name>
                  <is-service>false</is-service>
                  <mode-group UUID="5de6bb25-e952-4b16-ad52-f4692d7da6d9">
                    <short-name>ModeGroup</short-name>
                    <type-tref DEST="MODE-DECLARATION-GROUP">/SharedElements/PortInterfaces/ModeSwitch/Copy_ModeDeclarationGroup</type-tref>
                    </mode-group>
                  </mode-switch-interface>
                <mode-declaration-group UUID="b9ed1cc5-6caf-43d0-b094-3c763b6cbb9a">
                  <short-name>ModeDeclarationGroup</short-name>
                  <category>ALPHABETIC_ORDER</category>
                  <initial-mode-ref DEST="MODE-DECLARATION">/SharedElements/PortInterfaces/ModeSwitch/ModeDeclarationGroup/ModeDeclaration</initial-mode-ref>
                  <mode-declarations>
                    <mode-declaration UUID="c1fb19b0-d635-4deb-a718-37e3d20b8878">
                      <short-name>ModeDeclaration</short-name>
                      </mode-declaration>
                    <mode-declaration UUID="a586eb27-c099-42ab-b553-a0fd227d1fe5">
                      <short-name>ModeDeclaration1</short-name>
                      </mode-declaration>
                    <mode-declaration UUID="a891dd23-e1f6-41f0-b669-b383af7bd17e">
                      <short-name>ModeDeclaration2</short-name>
                      </mode-declaration>
                    </mode-declarations>
                  </mode-declaration-group>
                <mode-switch-interface UUID="949dcf4f-08eb-4d99-8504-1c613d93f5e9">
                  <short-name>ModeSwitchInterface</short-name>
                  <is-service>false</is-service>
                  <mode-group UUID="26ede937-ce36-4065-93e5-d8bca12d51cd">
                    <short-name>ModeGroup</short-name>
                    <type-tref DEST="MODE-DECLARATION-GROUP">/SharedElements/PortInterfaces/ModeSwitch/ModeDeclarationGroup</type-tref>
                    </mode-group>
                  </mode-switch-interface>
                </elements>
              </ar-package>
            <ar-package UUID="07677b4a-bc79-4c7b-afa1-581ad642a3dd">
              <short-name>NvData</short-name>
              <elements>
                <nv-data-interface UUID="8a4989b3-88e2-4e47-b98f-591e75c76b17">
                  <short-name>NvDataInterface</short-name>
                  <is-service>false</is-service>
                  <nv-datas>
                    <variable-data-prototype UUID="8a84bf2f-0e49-4923-bbc2-7a6606812ef4">
                      <short-name>NvData</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="4437f330-788c-4fb4-92e5-9545dfdbd9f0">
                      <short-name>NvData1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/float64</type-tref>
                      </variable-data-prototype>
                    </nv-datas>
                  </nv-data-interface>
                </elements>
              </ar-package>
            <ar-package UUID="9b48ec34-87aa-4f84-9080-1d3f919ca090">
              <short-name>Parameter</short-name>
              <elements>
                <parameter-interface UUID="618ca0ee-adf8-43c1-b898-33ea5ca916d8">
                  <short-name>ParameterInterface</short-name>
                  <is-service>false</is-service>
                  <parameters>
                    <parameter-data-prototype UUID="d359a294-51b2-461a-b7fb-0de80cf2598a">
                      <short-name>Parameter</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/float32</type-tref>
                      </parameter-data-prototype>
                    <parameter-data-prototype UUID="a60e4821-63b4-4fa4-9f04-983264b2a55f">
                      <short-name>Parameter1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                      </parameter-data-prototype>
                    </parameters>
                  </parameter-interface>
                </elements>
              </ar-package>
            <ar-package UUID="304f7bbd-15e6-4f85-b22f-4b02c9a5631c">
              <short-name>SenderReceiver</short-name>
              <elements>
                <sender-receiver-interface UUID="5301b51c-ab80-4717-880a-f53963ebb47d">
                  <short-name>Copy2_SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="d071c034-64ed-44d0-81f0-a0735e373ce3">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="3afe6629-f986-4006-9ecf-b2902644f64e">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  </sender-receiver-interface>
                <sender-receiver-interface UUID="b4591ad1-c21f-4706-8eac-55f6169b8c96">
                  <short-name>Copy3_SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="dd322790-2f29-43dc-93a0-10c5addc7871">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="27292aab-8793-404f-b1d0-3128a4ab29bf">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  </sender-receiver-interface>
                <sender-receiver-interface UUID="e5b1f8fc-9e46-4d58-b278-cb3461917783">
                  <short-name>Copy4_SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="81fa7709-76a3-4e64-8ab6-0302340d9596">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="4139b239-b260-44f9-a1b9-26592a9702b7">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  </sender-receiver-interface>
                <sender-receiver-interface UUID="67583438-372e-4f89-aad7-44d221ba987e">
                  <short-name>Copy5_SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="b67450ea-eee7-49cd-9e1b-696114cdc06b">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="6616174f-78ab-48e5-b54f-f0ac623eefa6">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  </sender-receiver-interface>
                <sender-receiver-interface UUID="c0a51d5f-0a8c-4bdc-a77d-03a338508c6b">
                  <short-name>Copy_SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="b7a89eaf-844f-4e6d-b357-dc9976ba211e">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="373c6d56-b664-4bba-b6bf-37630aed9fef">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  </sender-receiver-interface>
                <sender-receiver-interface UUID="5f56a3f5-0f22-429f-a8b9-003d68bbc759">
                  <short-name>SenderReceiverInterface</short-name>
                  <is-service>false</is-service>
                  <data-elements>
                    <variable-data-prototype UUID="c448fbc4-20d2-443d-bb7a-87585742cfcf">
                      <short-name>DataElement</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/SharedElements/ApplicationDataTypes/Primitive/ApplicationPrimitiveDataType</type-tref>
                      </variable-data-prototype>
                    <variable-data-prototype UUID="6862a5ea-8794-4906-9f54-50624e9d6044">
                      <short-name>DataElement1</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint32</type-tref>
                      </variable-data-prototype>
                    </data-elements>
                  <invalidation-policys>
                    <invalidation-policy>
                      <data-element-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</data-element-ref>
                      <handle-invalid>KEEP</handle-invalid>
                      </invalidation-policy>
                    </invalidation-policys>
                  </sender-receiver-interface>
                </elements>
              </ar-package>
            <ar-package UUID="00421379-584f-4dbb-8c9f-d70ad66b8e41">
              <short-name>Trigger</short-name>
              <elements>
                <trigger-interface UUID="97d54491-56c6-49b9-9812-bb5eadaefa82">
                  <short-name>TriggerInterface</short-name>
                  <is-service>false</is-service>
                  <triggers>
                    <trigger UUID="06d545dc-664d-45fb-be23-8a076bded4b5">
                      <short-name>Trigger</short-name>
                      <sw-impl-policy>STANDARD</sw-impl-policy>
                      <trigger-period>
                        <cse-code>6</cse-code>
                        <cse-code-factor>15</cse-code-factor>
                        </trigger-period>
                      </trigger>
                    </triggers>
                  </trigger-interface>
                </elements>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package UUID="a21c4095-c5dd-41b4-8a15-aa23a460a3e9">
          <short-name>SWCImpl</short-name>
          <elements>
            <swc-implementation UUID="a8e1b9bd-bc2d-4bba-8d84-7fb588da487b">
              <short-name>SwcImplementation</short-name>
              <programming-language>C</programming-language>
              <resource-consumption UUID="664bf3d9-9efc-49d1-a4fd-9936922aa5f9">
                <short-name>ResourceConsumption</short-name>
                </resource-consumption>
              <sw-version>1.0.0.0</sw-version>
              <behavior-ref DEST="SWC-INTERNAL-BEHAVIOR">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl</behavior-ref>
              </swc-implementation>
            </elements>
          </ar-package>
        <ar-package UUID="fc8b946c-31d4-49d6-8e0c-ff6847ede7f5">
          <short-name>SwAddrMethods</short-name>
          <elements>
            <sw-addr-method UUID="8a973d95-6644-4157-ab41-c78f7ccbcb2c">
              <short-name>Copy2_SwAddrMethod</short-name>
              <memory-allocation-keyword-policy>ADDR-METHOD-SHORT-NAME</memory-allocation-keyword-policy>
              <section-type>CODE</section-type>
              </sw-addr-method>
            <sw-addr-method UUID="73ccfb92-d7eb-4aee-b724-b520ed1a3e84">
              <short-name>Copy_SwAddrMethod</short-name>
              <memory-allocation-keyword-policy>ADDR-METHOD-SHORT-NAME-AND-ALIGNMENT</memory-allocation-keyword-policy>
              <section-type>CALIBRATION-VARIABLES</section-type>
              </sw-addr-method>
            <sw-addr-method UUID="59a8a159-68d8-4804-8d3b-76f1a5d48b3c">
              <short-name>SwAddrMethod</short-name>
              <memory-allocation-keyword-policy>ADDR-METHOD-SHORT-NAME</memory-allocation-keyword-policy>
              <section-type>CALIBRATION-VARIABLES</section-type>
              </sw-addr-method>
            </elements>
          </ar-package>
        </ar-packages>
      </ar-package>
    <ar-package>
      <short-name>SwComponentTypes</short-name>
      <ar-packages>
        <ar-package UUID="7e1cfec7-fc85-4615-9df0-46ddc1fdaa09">
          <short-name>ApplSWC</short-name>
          <elements>
            <application-sw-component-type UUID="e74b1e65-d39d-460c-8d4d-d95c8a9e12dd">
              <short-name>ApplicationSwComponentType</short-name>
              <ports>
                <r-port-prototype UUID="1ecadefd-df18-4c05-a2d5-803778e62ae1">
                  <short-name>RPort_SR</short-name>
                  <required-interface-tref DEST="SENDER-RECEIVER-INTERFACE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface</required-interface-tref>
                  </r-port-prototype>
                <p-port-prototype UUID="a3e8969f-1dde-4749-af9a-f337b0f053d8">
                  <short-name>PPort_SR</short-name>
                  <provided-interface-tref DEST="SENDER-RECEIVER-INTERFACE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface</provided-interface-tref>
                  </p-port-prototype>
                <r-port-prototype UUID="933a7736-19ea-4662-8301-3fe9991367bc">
                  <short-name>RPort_CS</short-name>
                  <required-interface-tref DEST="CLIENT-SERVER-INTERFACE">/SharedElements/PortInterfaces/ClientServer/ClientServerInterface</required-interface-tref>
                  </r-port-prototype>
                <p-port-prototype UUID="38b3145f-1dd8-4a0f-943b-2f6b2d0a4221">
                  <short-name>PPort_CS</short-name>
                  <provided-interface-tref DEST="CLIENT-SERVER-INTERFACE">/SharedElements/PortInterfaces/ClientServer/ClientServerInterface</provided-interface-tref>
                  </p-port-prototype>
                <r-port-prototype UUID="08e53a34-e89a-4c1c-a2d4-9536c0e123af">
                  <short-name>RPort_msi</short-name>
                  <required-interface-tref DEST="MODE-SWITCH-INTERFACE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface</required-interface-tref>
                  </r-port-prototype>
                <p-port-prototype UUID="8ed933c7-270b-45cf-8a3e-206782153f61">
                  <short-name>PPort_msi</short-name>
                  <provided-interface-tref DEST="MODE-SWITCH-INTERFACE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface</provided-interface-tref>
                  </p-port-prototype>
                <r-port-prototype UUID="52c8bb91-6599-4bdd-a556-e2b22ab9c73b">
                  <short-name>RPort_nvd</short-name>
                  <required-interface-tref DEST="NV-DATA-INTERFACE">/SharedElements/PortInterfaces/NvData/NvDataInterface</required-interface-tref>
                  </r-port-prototype>
                <p-port-prototype UUID="a69f810c-0a9d-4729-9b49-5b4be2f55ffa">
                  <short-name>PPort_nvd</short-name>
                  <provided-interface-tref DEST="NV-DATA-INTERFACE">/SharedElements/PortInterfaces/NvData/NvDataInterface</provided-interface-tref>
                  </p-port-prototype>
                <r-port-prototype UUID="7bee2832-df48-4712-a0cf-9b2f095db921">
                  <short-name>RPort_prm</short-name>
                  <required-interface-tref DEST="PARAMETER-INTERFACE">/SharedElements/PortInterfaces/Parameter/ParameterInterface</required-interface-tref>
                  </r-port-prototype>
                <r-port-prototype UUID="9194fa9f-f535-4ef4-ad71-379f00251a5f">
                  <short-name>RPort_trigger</short-name>
                  <required-interface-tref DEST="TRIGGER-INTERFACE">/SharedElements/PortInterfaces/Trigger/TriggerInterface</required-interface-tref>
                  </r-port-prototype>
                </ports>
              <internal-behaviors>
                <swc-internal-behavior UUID="d0c29733-8863-4bcd-af6a-1579e0a29746">
                  <short-name>IB_Appl</short-name>
                  <constant-memorys>
                    <parameter-data-prototype UUID="666c53b0-408c-4084-8002-71810ad2bea7">
                      <short-name>ConstantMemory</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint64</type-tref>
                      <init-value>
                        <numerical-value-specification>
                          <short-label>Value</short-label>
                          <value>3</value>
                          </numerical-value-specification>
                        </init-value>
                      </parameter-data-prototype>
                    </constant-memorys>
                  <data-type-mapping-refs>
                    <data-type-mapping-ref DEST="DATA-TYPE-MAPPING-SET">/SharedElements/DataTypemappingSets/DataTypeMappingSet</data-type-mapping-ref>
                    </data-type-mapping-refs>
                  <static-memorys>
                    <variable-data-prototype UUID="0a83fe83-959c-49d2-abf1-981ac4641b7d">
                      <short-name>StaticMemory</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                      <init-value>
                        <constant-reference>
                          <short-label>ReferenceToConstant</short-label>
                          <constant-ref DEST="CONSTANT-SPECIFICATION">/SharedElements/ConstantSpecifications/ApplicationSwComponentType_StaticMemory</constant-ref>
                          </constant-reference>
                        </init-value>
                      </variable-data-prototype>
                    </static-memorys>
                  <ar-typed-per-instance-memorys>
                    <variable-data-prototype UUID="c2401b62-709c-4a61-a9d7-5f540d144075">
                      <short-name>ArTypedPerInstanceMemory</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/sint16</type-tref>
                      <init-value>
                        <numerical-value-specification>
                          <short-label>Value</short-label>
                          <value>-3</value>
                          </numerical-value-specification>
                        </init-value>
                      </variable-data-prototype>
                    </ar-typed-per-instance-memorys>
                  <events>
                    <asynchronous-server-call-returns-event UUID="98e66756-7475-4549-94ba-bd68dca85e27">
                      <short-name>AsynchronousServerCallReturnsEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable</start-on-event-ref>
                      <event-source-ref DEST="ASYNCHRONOUS-SERVER-CALL-RESULT-POINT">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable/AsynchronousServerCallResultPoint</event-source-ref>
                      </asynchronous-server-call-returns-event>
                    <background-event UUID="878975ea-f390-4f62-a34f-05ca7fd73896">
                      <short-name>BackgroundEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable1</start-on-event-ref>
                      </background-event>
                    <data-receive-error-event UUID="733de305-2dc6-4ac2-be25-134d242372ad">
                      <short-name>DataReceiveErrorEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable2</start-on-event-ref>
                      <data-iref>
                        <context-r-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</context-r-port-ref>
                        <target-data-element-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-element-ref>
                        </data-iref>
                      </data-receive-error-event>
                    <data-received-event UUID="30fc9c83-5302-44fc-a25d-0d77e2b3d112">
                      <short-name>DataReceivedEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable3</start-on-event-ref>
                      <data-iref>
                        <context-r-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</context-r-port-ref>
                        <target-data-element-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-element-ref>
                        </data-iref>
                      </data-received-event>
                    <data-send-completed-event UUID="aefde323-2cf9-4226-aedb-0a1a33876a55">
                      <short-name>DataSendCompletedEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable4</start-on-event-ref>
                      <event-source-ref DEST="VARIABLE-ACCESS">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable4/DSP_PPort_SR_DataElement</event-source-ref>
                      </data-send-completed-event>
                    <data-write-completed-event UUID="0da70404-5ab6-4651-ad56-e1c3adab06e5">
                      <short-name>DataWriteCompletedEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable5</start-on-event-ref>
                      <event-source-ref DEST="VARIABLE-ACCESS">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable5/DWA_PPort_SR_DataElement1</event-source-ref>
                      </data-write-completed-event>
                    <external-trigger-occurred-event UUID="7f122189-5a69-4e28-af84-b5a1e73c9206">
                      <short-name>ExternalTriggerOccurredEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable6</start-on-event-ref>
                      <trigger-iref>
                        <context-r-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_trigger</context-r-port-ref>
                        <target-trigger-ref DEST="TRIGGER">/SharedElements/PortInterfaces/Trigger/TriggerInterface/Trigger</target-trigger-ref>
                        </trigger-iref>
                      </external-trigger-occurred-event>
                    <init-event UUID="6febdb10-eefc-44b9-adad-fdef91bbef72">
                      <short-name>InitEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable7</start-on-event-ref>
                      </init-event>
                    <mode-switched-ack-event UUID="2f5c24be-60cf-4249-bfde-ceabef6d00d4">
                      <short-name>ModeSwitchedAckEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable9</start-on-event-ref>
                      <event-source-ref DEST="MODE-SWITCH-POINT">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable9/MSP_PPort_msi_ModeGroup</event-source-ref>
                      </mode-switched-ack-event>
                    <operation-invoked-event UUID="02646a86-1109-43a4-8e09-cb8878e932a5">
                      <short-name>OperationInvokedEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable10</start-on-event-ref>
                      <operation-iref>
                        <context-p-port-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_CS</context-p-port-ref>
                        <target-provided-operation-ref DEST="CLIENT-SERVER-OPERATION">/SharedElements/PortInterfaces/ClientServer/ClientServerInterface/Operation1</target-provided-operation-ref>
                        </operation-iref>
                      </operation-invoked-event>
                    <swc-mode-manager-error-event UUID="2e3337be-0df8-4dce-a65a-ca8bb234754a">
                      <short-name>SwcModeManagerErrorEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable11</start-on-event-ref>
                      <mode-group-iref>
                        <context-p-port-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_msi</context-p-port-ref>
                        <target-mode-group-ref DEST="MODE-DECLARATION-GROUP-PROTOTYPE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface/ModeGroup</target-mode-group-ref>
                        </mode-group-iref>
                      </swc-mode-manager-error-event>
                    <swc-mode-switch-event UUID="5bebf915-dc23-4d8d-ac15-4af9a83cb9f1">
                      <short-name>SwcModeSwitchEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable12</start-on-event-ref>
                      <activation>ON-TRANSITION</activation>
                      <mode-irefs>
                        <mode-iref>
                          <context-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_msi</context-port-ref>
                          <context-mode-declaration-group-prototype-ref DEST="MODE-DECLARATION-GROUP-PROTOTYPE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface/ModeGroup</context-mode-declaration-group-prototype-ref>
                          <target-mode-declaration-ref DEST="MODE-DECLARATION">/SharedElements/PortInterfaces/ModeSwitch/ModeDeclarationGroup/ModeDeclaration2</target-mode-declaration-ref>
                          </mode-iref>
                        <mode-iref>
                          <context-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_msi</context-port-ref>
                          <context-mode-declaration-group-prototype-ref DEST="MODE-DECLARATION-GROUP-PROTOTYPE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface/ModeGroup</context-mode-declaration-group-prototype-ref>
                          <target-mode-declaration-ref DEST="MODE-DECLARATION">/SharedElements/PortInterfaces/ModeSwitch/ModeDeclarationGroup/ModeDeclaration</target-mode-declaration-ref>
                          </mode-iref>
                        </mode-irefs>
                      </swc-mode-switch-event>
                    <timing-event UUID="a761b6cb-cd31-4a99-b2f8-21c5a132097e">
                      <short-name>TimingEvent</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable13</start-on-event-ref>
                      <period>0.01</period>
                      </timing-event>
                    <timing-event UUID="0faaa505-7947-4b84-b8ea-4086fa60a54c">
                      <short-name>TimingEvent1</short-name>
                      <start-on-event-ref DEST="RUNNABLE-ENTITY">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable15</start-on-event-ref>
                      <period>0.01</period>
                      </timing-event>
                    </events>
                  <explicit-inter-runnable-variables>
                    <variable-data-prototype UUID="46bf0c15-16f3-428f-92de-ce374a9faf1c">
                      <short-name>ExplicitInterRunnableVariable</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/boolean</type-tref>
                      <init-value>
                        <constant-reference>
                          <short-label>ReferenceToConstant</short-label>
                          <constant-ref DEST="CONSTANT-SPECIFICATION">/SharedElements/ConstantSpecifications/ApplicationSwComponentType_ExplicitInterRunnableVariable</constant-ref>
                          </constant-reference>
                        </init-value>
                      </variable-data-prototype>
                    </explicit-inter-runnable-variables>
                  <handle-termination-and-restart>NO-SUPPORT</handle-termination-and-restart>
                  <implicit-inter-runnable-variables>
                    <variable-data-prototype UUID="100df329-69ca-4527-945c-b23a59017964">
                      <short-name>ImplicitInterRunnableVariable</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/sint16</type-tref>
                      <init-value>
                        <numerical-value-specification>
                          <short-label>Value</short-label>
                          <value>0</value>
                          </numerical-value-specification>
                        </init-value>
                      </variable-data-prototype>
                    </implicit-inter-runnable-variables>
                  <per-instance-parameters>
                    <parameter-data-prototype UUID="a2509010-a816-4ea4-b0ed-c5ba10c3ca78">
                      <short-name>PerInstanceParameter</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/uint8</type-tref>
                      <init-value>
                        <numerical-value-specification>
                          <short-label>Value</short-label>
                          <value>5</value>
                          </numerical-value-specification>
                        </init-value>
                      </parameter-data-prototype>
                    </per-instance-parameters>
                  <runnables>
                    <runnable-entity UUID="bfb2d01b-9082-4a58-a929-6d7a860a2d9a">
                      <short-name>Runnable</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <sw-addr-method-ref DEST="SW-ADDR-METHOD">/SharedElements/SwAddrMethods/Copy2_SwAddrMethod</sw-addr-method-ref>
                      <asynchronous-server-call-result-points>
                        <asynchronous-server-call-result-point UUID="f857d505-3c25-43b2-b929-36e0e40f1177">
                          <short-name>AsynchronousServerCallResultPoint</short-name>
                          <asynchronous-server-call-point-ref DEST="ASYNCHRONOUS-SERVER-CALL-POINT">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/Runnable/ASCP_RPort_CS_Operation</asynchronous-server-call-point-ref>
                          </asynchronous-server-call-result-point>
                        </asynchronous-server-call-result-points>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <server-call-points>
                        <asynchronous-server-call-point UUID="e7aacef3-56e7-4964-b0b6-5569dd4abc09">
                          <short-name>ASCP_RPort_CS_Operation</short-name>
                          <operation-iref>
                            <context-r-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_CS</context-r-port-ref>
                            <target-required-operation-ref DEST="CLIENT-SERVER-OPERATION">/SharedElements/PortInterfaces/ClientServer/ClientServerInterface/Operation</target-required-operation-ref>
                            </operation-iref>
                          <timeout>0</timeout>
                          </asynchronous-server-call-point>
                        </server-call-points>
                      <symbol>ApplicationSwComponentType_Runnable</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="4a40f3ec-f4dd-4ab0-8562-6a5174f2901e">
                      <short-name>Runnable1</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable1</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="83eca00a-85d5-4f04-9573-3d997cd29b67">
                      <short-name>Runnable2</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable2</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="20bfd5e2-a118-4324-97fd-dcd5bf5f0a46">
                      <short-name>Runnable3</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable3</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="ae315d13-a18a-4515-b02d-f1b207f85e47">
                      <short-name>Runnable4</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <data-send-points>
                        <variable-access UUID="2a04aecc-a1b6-494f-838e-29671adb5210">
                          <short-name>DSP_PPort_SR_DataElement</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-send-points>
                      <symbol>ApplicationSwComponentType_Runnable4</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="3ea0641c-9d79-4f93-8287-e34956b5c134">
                      <short-name>Runnable5</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <data-write-accesss>
                        <variable-access UUID="326a474d-8d28-41bc-bd9e-91de9802f682">
                          <short-name>DWA_PPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-write-accesss>
                      <symbol>ApplicationSwComponentType_Runnable5</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="d7adad0b-22d1-4b37-9691-0677036197aa">
                      <short-name>Runnable6</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable6</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="98d30ebd-bbcb-4780-bc4a-27e6fd798a5a">
                      <short-name>Runnable7</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable7</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="a6d9d7cb-1d57-45f2-b36a-1e1ab717fb1e">
                      <short-name>Runnable9</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <mode-switch-points>
                        <mode-switch-point UUID="dd700e44-3e29-4b21-901f-c2e36c719f6a">
                          <short-name>MSP_PPort_msi_ModeGroup</short-name>
                          <mode-group-iref>
                            <context-p-port-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_msi</context-p-port-ref>
                            <target-mode-group-ref DEST="MODE-DECLARATION-GROUP-PROTOTYPE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface/ModeGroup</target-mode-group-ref>
                            </mode-group-iref>
                          </mode-switch-point>
                        </mode-switch-points>
                      <symbol>ApplicationSwComponentType_Runnable9</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="3d515ac9-9c51-4cb8-a6af-ea16d3afd01d">
                      <short-name>Runnable10</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable10</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="9bddd887-575d-463b-b09d-d1b63ec1352b">
                      <short-name>Runnable11</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable11</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="fa96688f-7ffe-4b3b-aa43-c124847e2efd">
                      <short-name>Runnable12</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable12</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="e967670f-46d8-4d91-b4b9-62c85a17843e">
                      <short-name>Runnable13</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <data-read-accesss>
                        <variable-access UUID="9bf42611-5276-4ce4-92b5-36c024121479">
                          <short-name>DRA_RPort_SR_DataElement</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="9eef2638-b3d9-47c1-9e18-37822b089dd4">
                          <short-name>DRA_RPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="26ad84a0-bc71-4cae-92f7-69d3d1bc91ff">
                          <short-name>DRA_RPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="067aa426-f94d-4f7c-b471-a3631398a8a6">
                          <short-name>DRA_RPort_nvd_NvData1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-read-accesss>
                      <data-write-accesss>
                        <variable-access UUID="a0b4f337-7b3c-4ade-bc28-db75b0882305">
                          <short-name>DWA_PPort_SR_DataElement</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="839b63ac-ec02-4b70-aca8-f974d2ab728c">
                          <short-name>DWA_PPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="b68d4be0-8b3f-4259-9c8a-2901c17454d7">
                          <short-name>DWA_PPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="3e84de24-a491-4152-b344-8c5e44e9197e">
                          <short-name>DWA_PPort_nvd_NvData1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-write-accesss>
                      <read-local-variables>
                        <variable-access UUID="c8972fdb-f78a-4e12-9a30-4faf0daa6c23">
                          <short-name>IRVRA_ExplicitInterRunnableVariable</short-name>
                          <accessed-variable>
                            <local-variable-ref DEST="VARIABLE-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/ExplicitInterRunnableVariable</local-variable-ref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="bf16d1d1-6833-4572-8830-6e31aa069454">
                          <short-name>IRVRA_ImplicitInterRunnableVariable</short-name>
                          <accessed-variable>
                            <local-variable-ref DEST="VARIABLE-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/ImplicitInterRunnableVariable</local-variable-ref>
                            </accessed-variable>
                          </variable-access>
                        </read-local-variables>
                      <symbol>ApplicationSwComponentType_Runnable13</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="1c2e8cb0-fdf5-45ee-9257-dee6f42d2ad4">
                      <short-name>Runnable14</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <symbol>ApplicationSwComponentType_Runnable14</symbol>
                      </runnable-entity>
                    <runnable-entity UUID="6debf2b3-9c4c-455e-9cbc-0c7cfaca4d43">
                      <short-name>Runnable15</short-name>
                      <minimum-start-interval>0</minimum-start-interval>
                      <can-be-invoked-concurrently>false</can-be-invoked-concurrently>
                      <data-read-accesss>
                        <variable-access UUID="5648b05b-23f8-4729-9fdd-25a617e2d17b">
                          <short-name>DRA_RPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="b355b0ac-1fa9-43f7-b5ab-240eae2c3694">
                          <short-name>DRA_RPort_nvd_NvData1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-read-accesss>
                      <data-receive-point-by-arguments>
                        <variable-access UUID="86796258-06a6-480e-8a39-e01411743a56">
                          <short-name>DRP_RPort_SR_DataElement</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="88c27605-b9a2-4db7-af10-2a0953c5110b">
                          <short-name>DRP_RPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="b69ad602-c226-42a5-9bbb-acbbc5c16743">
                          <short-name>DRP_RPort_nvd_NvData1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-receive-point-by-arguments>
                      <data-receive-point-by-values>
                        <variable-access UUID="38ed8447-65f1-48a9-b075-fa613c1267d2">
                          <short-name>DRPV_RPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="d07d7e6b-0d9c-4475-bbb9-2ccfc3e60c33">
                          <short-name>DRPV_RPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-receive-point-by-values>
                      <data-send-points>
                        <variable-access UUID="2fc872c8-d598-4d11-8502-1a70e9104bc9">
                          <short-name>DSP_PPort_SR_DataElement</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="a2f22836-4cd0-4c2e-8040-1abdf8935ac0">
                          <short-name>DSP_PPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="c0c41eb1-b5bf-4e30-9569-24d7316b64c8">
                          <short-name>DSP_PPort_nvd_NvData</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="96f66382-5f86-4a47-bd5b-9f95f81fc3c9">
                          <short-name>DSP_PPort_nvd_NvData1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_nvd</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/NvData/NvDataInterface/NvData1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-send-points>
                      <data-write-accesss>
                        <variable-access UUID="d40a6e94-d8e5-48e5-8a1a-c7debe02592f">
                          <short-name>DWA_PPort_SR_DataElement1</short-name>
                          <accessed-variable>
                            <autosar-variable-iref>
                              <port-prototype-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_SR</port-prototype-ref>
                              <target-data-prototype-ref DEST="VARIABLE-DATA-PROTOTYPE">/SharedElements/PortInterfaces/SenderReceiver/SenderReceiverInterface/DataElement1</target-data-prototype-ref>
                              </autosar-variable-iref>
                            </accessed-variable>
                          </variable-access>
                        </data-write-accesss>
                      <mode-switch-points>
                        <mode-switch-point UUID="8f7d9801-a32d-4e5f-85cd-fbcf669d921a">
                          <short-name>MSP_PPort_msi_ModeGroup</short-name>
                          <mode-group-iref>
                            <context-p-port-ref DEST="P-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/PPort_msi</context-p-port-ref>
                            <target-mode-group-ref DEST="MODE-DECLARATION-GROUP-PROTOTYPE">/SharedElements/PortInterfaces/ModeSwitch/ModeSwitchInterface/ModeGroup</target-mode-group-ref>
                            </mode-group-iref>
                          </mode-switch-point>
                        </mode-switch-points>
                      <parameter-accesss>
                        <parameter-access UUID="92d672aa-34ea-4fcb-a0a2-ab2431d59c0a">
                          <short-name>ParameterAccess</short-name>
                          <accessed-parameter>
                            <local-parameter-ref DEST="PARAMETER-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/ConstantMemory</local-parameter-ref>
                            </accessed-parameter>
                          </parameter-access>
                        <parameter-access UUID="391726ca-20e2-4c02-b063-65244a9e523a">
                          <short-name>PICPVA_PerInstanceParameter</short-name>
                          <accessed-parameter>
                            <local-parameter-ref DEST="PARAMETER-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/PerInstanceParameter</local-parameter-ref>
                            </accessed-parameter>
                          </parameter-access>
                        <parameter-access UUID="19d7aee6-82b8-4233-a787-b84bdb562167">
                          <short-name>CPA_RPort_prm_Parameter</short-name>
                          <accessed-parameter>
                            <autosar-parameter-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_prm</port-prototype-ref>
                              <target-data-prototype-ref DEST="PARAMETER-DATA-PROTOTYPE">/SharedElements/PortInterfaces/Parameter/ParameterInterface/Parameter</target-data-prototype-ref>
                              </autosar-parameter-iref>
                            </accessed-parameter>
                          </parameter-access>
                        <parameter-access UUID="ab7c5c59-47f3-4fee-a310-f64cb2c00c48">
                          <short-name>CPA_RPort_prm_Parameter1</short-name>
                          <accessed-parameter>
                            <autosar-parameter-iref>
                              <port-prototype-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_prm</port-prototype-ref>
                              <target-data-prototype-ref DEST="PARAMETER-DATA-PROTOTYPE">/SharedElements/PortInterfaces/Parameter/ParameterInterface/Parameter1</target-data-prototype-ref>
                              </autosar-parameter-iref>
                            </accessed-parameter>
                          </parameter-access>
                        <parameter-access UUID="f7d2bfa9-92c5-4627-b238-86aadd05585b">
                          <short-name>SCPVA_SharedParameter</short-name>
                          <accessed-parameter>
                            <local-parameter-ref DEST="PARAMETER-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/SharedParameter</local-parameter-ref>
                            </accessed-parameter>
                          </parameter-access>
                        </parameter-accesss>
                      <server-call-points>
                        <synchronous-server-call-point UUID="d6a93f51-be57-4a77-bd8f-e25d3e0ba149">
                          <short-name>SSCP_RPort_CS_Operation1</short-name>
                          <operation-iref>
                            <context-r-port-ref DEST="R-PORT-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/RPort_CS</context-r-port-ref>
                            <target-required-operation-ref DEST="CLIENT-SERVER-OPERATION">/SharedElements/PortInterfaces/ClientServer/ClientServerInterface/Operation1</target-required-operation-ref>
                            </operation-iref>
                          <timeout>0</timeout>
                          </synchronous-server-call-point>
                        </server-call-points>
                      <symbol>ApplicationSwComponentType_Runnable15</symbol>
                      <written-local-variables>
                        <variable-access UUID="7e246e9c-b78a-47be-8798-02887c881e6e">
                          <short-name>IRVWA_ExplicitInterRunnableVariable</short-name>
                          <accessed-variable>
                            <local-variable-ref DEST="VARIABLE-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/ExplicitInterRunnableVariable</local-variable-ref>
                            </accessed-variable>
                          </variable-access>
                        <variable-access UUID="d976bba9-3132-4e15-ac45-88b85facf508">
                          <short-name>IRVWA_ImplicitInterRunnableVariable</short-name>
                          <accessed-variable>
                            <local-variable-ref DEST="VARIABLE-DATA-PROTOTYPE">/SwComponentTypes/ApplSWC/ApplicationSwComponentType/IB_Appl/ImplicitInterRunnableVariable</local-variable-ref>
                            </accessed-variable>
                          </variable-access>
                        </written-local-variables>
                      </runnable-entity>
                    </runnables>
                  <shared-parameters>
                    <parameter-data-prototype UUID="edf877b4-19ea-4e47-8180-a74099cfff0f">
                      <short-name>SharedParameter</short-name>
                      <sw-data-def-props>
                        <sw-data-def-props-variants>
                          <sw-data-def-props-conditional>
                            <sw-calibration-access>READ-WRITE</sw-calibration-access>
                            <sw-impl-policy>STANDARD</sw-impl-policy>
                            </sw-data-def-props-conditional>
                          </sw-data-def-props-variants>
                        </sw-data-def-props>
                      <type-tref DEST="IMPLEMENTATION-DATA-TYPE">/AUTOSAR/AUTOSAR_Platform/ImplementationDataTypes/float32</type-tref>
                      <init-value>
                        <constant-reference>
                          <short-label>ReferenceToConstant</short-label>
                          <constant-ref DEST="CONSTANT-SPECIFICATION">/SharedElements/ConstantSpecifications/ApplicationSwComponentType_SharedParameter</constant-ref>
                          </constant-reference>
                        </init-value>
                      </parameter-data-prototype>
                    </shared-parameters>
                  <supports-multiple-instantiation>false</supports-multiple-instantiation>
                  </swc-internal-behavior>
                </internal-behaviors>
              </application-sw-component-type>
            </elements>
          <ar-packages>
            <ar-package UUID="0f00b99f-27e3-434f-9d85-398fc7c29067">
              <short-name>ConstantSpecifications</short-name>
              </ar-package>
            </ar-packages>
          </ar-package>
        <ar-package UUID="7f0b665f-81ab-462f-aeab-1777b0f9dfd8">
          <short-name>CddSWC</short-name>
          <elements>
            <complex-device-driver-sw-component-type UUID="27755bdf-1bfe-447f-bfdf-54402e4f4db3">
              <short-name>ComplexDeviceDriverSwComponentType</short-name>
              </complex-device-driver-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="a9d129de-eda4-4cda-9025-70a56f38fb59">
          <short-name>CompSWC</short-name>
          <elements>
            <composition-sw-component-type UUID="9e886193-6d1b-454f-98b2-d0347db57ace">
              <short-name>CompositionSwComponentType</short-name>
              </composition-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="28aa9cf2-4118-4878-8504-271a3ed4600b">
          <short-name>EcuAbSWC</short-name>
          <elements>
            <ecu-abstraction-sw-component-type UUID="0dc33c67-8b23-4896-b6a3-8a537f1cd166">
              <short-name>EcuAbstractionSwComponentType</short-name>
              </ecu-abstraction-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="8562405a-26a1-4c3d-861f-eb0745310572">
          <short-name>NvDataSWC</short-name>
          <elements>
            <nv-block-sw-component-type UUID="9a2c1578-3f64-4af0-b953-7b81f28434cf">
              <short-name>NvBlockSwComponentType</short-name>
              </nv-block-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="0a54c44d-f71e-4ec3-bbf1-410c0b885915">
          <short-name>PrmSWC</short-name>
          <elements>
            <parameter-sw-component-type UUID="c21a6d07-19ae-40ac-affe-f4aa3b5acb25">
              <short-name>ParameterSwComponentType</short-name>
              </parameter-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="f142ef66-4dce-4750-8568-a7e836f462da">
          <short-name>SnsrActSWC</short-name>
          <elements>
            <sensor-actuator-sw-component-type UUID="e631e3e3-9a52-4bbe-a762-4311d8f45934">
              <short-name>SensorActuatorSwComponentType</short-name>
              </sensor-actuator-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="60bb3f96-0a5c-4e30-bdda-5205f3a1cdb6">
          <short-name>SrvcPrxySWC</short-name>
          <elements>
            <service-proxy-sw-component-type UUID="7e09780f-aad2-4f70-8c22-e5e19f1a82e8">
              <short-name>ServiceProxySwComponentType</short-name>
              </service-proxy-sw-component-type>
            </elements>
          </ar-package>
        <ar-package UUID="2ed6bb1a-c9d6-46c0-ae8b-0743080405b6">
          <short-name>SrvcSWC</short-name>
          <elements>
            <service-sw-component-type UUID="1da8de22-a6ec-4cab-829a-56300097c5ac">
              <short-name>ServiceSwComponentType</short-name>
              </service-sw-component-type>
            </elements>
          </ar-package>
        </ar-packages>
      </ar-package>
    <ar-package>
      <short-name>Systems</short-name>
      </ar-package>
    </ar-packages>
  </AUTOSAR>
