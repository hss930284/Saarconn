<?xml version="1.0" encoding="utf-8"?>
<!--Created with SystemDesk Release 2023-B (23.1p1)-->
<AUTOSAR xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xmlns="http://autosar.org/schema/r4.0" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00051.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE>
      <SHORT-NAME>SwComponentTypes</SHORT-NAME>
        <AR-PACKAGE>
          <SHORT-NAME>ApplSWC</SHORT-NAME>
        </AR-PACKAGE>
    </AR-PACKAGE>
    <AR-PACKAGE>
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>